* Extracted by KLayout with GF180 LVS runset on : 16/02/2023 12:57

.SUBCKT bootstrapper
X$1 VLO \$5 \$509 VGATE dnw_pfet
X$2 VLO VGATE \$509 VHI dnw_pfet
M$1 VHI CLK CLKn VHI pfet_03v3 L=0.28U W=2.5U AS=1.1P AD=0.65P PS=5.88U PD=3.02U
M$2 CLKn CLK VHI VHI pfet_03v3 L=0.28U W=2.5U AS=0.65P AD=0.65P PS=3.02U
+ PD=3.02U
M$3 VHI CLK CLKn VHI pfet_03v3 L=0.28U W=2.5U AS=0.65P AD=0.65P PS=3.02U
+ PD=3.02U
M$4 CLKn CLK VHI VHI pfet_03v3 L=0.28U W=2.5U AS=0.65P AD=1.1P PS=3.02U PD=5.88U
M$5 VHI CLK \$5 VHI pfet_03v3 L=0.28U W=0.5U AS=0.22P AD=0.13P PS=1.88U PD=1.02U
M$6 \$5 CLK VHI VHI pfet_03v3 L=0.28U W=0.5U AS=0.13P AD=0.22P PS=1.02U PD=1.88U
M$7 VGATE VHI \$391 gf180mcu_gnd nfet_03v3 L=0.28U W=5U AS=2.2P AD=1.3P
+ PS=10.88U PD=5.52U
M$8 \$391 VHI VGATE gf180mcu_gnd nfet_03v3 L=0.28U W=5U AS=1.3P AD=1.3P
+ PS=5.52U PD=5.52U
M$9 VGATE VHI \$392 gf180mcu_gnd nfet_03v3 L=0.28U W=5U AS=1.3P AD=1.3P
+ PS=5.52U PD=5.52U
M$10 \$392 VHI VGATE gf180mcu_gnd nfet_03v3 L=0.28U W=5U AS=1.3P AD=2.2P
+ PS=5.52U PD=10.88U
M$11 VLO CLKn \$391 gf180mcu_gnd nfet_03v3 L=0.28U W=5U AS=2.2P AD=1.3P
+ PS=10.88U PD=5.52U
M$12 \$391 CLKn VLO gf180mcu_gnd nfet_03v3 L=0.28U W=5U AS=1.3P AD=1.3P
+ PS=5.52U PD=5.52U
M$13 VLO CLKn \$392 gf180mcu_gnd nfet_03v3 L=0.28U W=5U AS=1.3P AD=1.3P
+ PS=5.52U PD=5.52U
M$14 \$392 CLKn VLO gf180mcu_gnd nfet_03v3 L=0.28U W=5U AS=1.3P AD=2.2P
+ PS=5.52U PD=10.88U
M$15 VLO CLK CLKn gf180mcu_gnd nfet_03v3 L=0.28U W=2U AS=0.88P AD=0.52P
+ PS=4.88U PD=2.52U
M$16 CLKn CLK VLO gf180mcu_gnd nfet_03v3 L=0.28U W=2U AS=0.52P AD=0.88P
+ PS=2.52U PD=4.88U
M$17 VLO CLKn \$7 gf180mcu_gnd nfet_03v3 L=0.28U W=2U AS=0.88P AD=0.52P
+ PS=4.88U PD=2.52U
M$18 \$7 CLKn VLO gf180mcu_gnd nfet_03v3 L=0.28U W=2U AS=0.52P AD=0.88P
+ PS=2.52U PD=4.88U
M$19 \$7 CLK \$5 gf180mcu_gnd nfet_03v3 L=0.28U W=1U AS=0.44P AD=0.26P PS=2.88U
+ PD=1.52U
M$20 \$5 CLK \$7 gf180mcu_gnd nfet_03v3 L=0.28U W=1U AS=0.26P AD=0.44P PS=1.52U
+ PD=2.88U
M$21 \$7 VGATE VIN gf180mcu_gnd nfet_03v3 L=0.28U W=2.5U AS=1.1P AD=0.65P
+ PS=5.88U PD=3.02U
M$22 VIN VGATE \$7 gf180mcu_gnd nfet_03v3 L=0.28U W=2.5U AS=0.65P AD=0.65P
+ PS=3.02U PD=3.02U
M$23 \$7 VGATE VIN gf180mcu_gnd nfet_03v3 L=0.28U W=2.5U AS=0.65P AD=0.65P
+ PS=3.02U PD=3.02U
M$24 VIN VGATE \$7 gf180mcu_gnd nfet_03v3 L=0.28U W=2.5U AS=0.65P AD=1.1P
+ PS=3.02U PD=5.88U
M$25 \$7 VGATE \$5 gf180mcu_gnd nfet_03v3 L=0.28U W=2.5U AS=1.1P AD=0.65P
+ PS=5.88U PD=3.02U
M$26 \$5 VGATE \$7 gf180mcu_gnd nfet_03v3 L=0.28U W=2.5U AS=0.65P AD=0.65P
+ PS=3.02U PD=3.02U
M$27 \$7 VGATE \$5 gf180mcu_gnd nfet_03v3 L=0.28U W=2.5U AS=0.65P AD=0.65P
+ PS=3.02U PD=3.02U
M$28 \$5 VGATE \$7 gf180mcu_gnd nfet_03v3 L=0.28U W=2.5U AS=0.65P AD=1.1P
+ PS=3.02U PD=5.88U
.ENDS bootstrapper

.SUBCKT dnw_pfet VLO G SDSUB SD
M$1 SDSUB G SD SDSUB pfet_03v3_dn L=0.28U W=2.5U AS=1.1P AD=0.65P PS=5.88U
+ PD=3.02U
M$2 SD G SDSUB SDSUB pfet_03v3_dn L=0.28U W=2.5U AS=0.65P AD=0.65P PS=3.02U
+ PD=3.02U
M$3 SDSUB G SD SDSUB pfet_03v3_dn L=0.28U W=2.5U AS=0.65P AD=0.65P PS=3.02U
+ PD=3.02U
M$4 SD G SDSUB SDSUB pfet_03v3_dn L=0.28U W=2.5U AS=0.65P AD=1.1P PS=3.02U
+ PD=5.88U
.ENDS dnw_pfet
