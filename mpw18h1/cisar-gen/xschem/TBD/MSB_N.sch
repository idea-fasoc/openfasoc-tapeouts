v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 940 -1700 980 -1700 {
lab=vgateN}
N 940 -1680 980 -1680 {
lab=VIN}
N 1280 -1700 1310 -1700 {
lab=VCM}
N 1280 -1680 1310 -1680 {
lab=VCM_1}
N 1280 -1660 1310 -1660 {
lab=agnd}
N 1280 -1640 1310 -1640 {
lab=CLK1D}
N 490 -1700 530 -1700 {
lab=vgateN}
N 490 -1680 530 -1680 {
lab=VIN}
N 830 -1700 860 -1700 {
lab=VCM}
N 830 -1680 860 -1680 {
lab=VCM_1}
N 830 -1660 860 -1660 {
lab=agnd}
N 830 -1640 860 -1640 {
lab=CLKR[7]}
N 40 -1690 80 -1690 {
lab=vgateN}
N 40 -1670 80 -1670 {
lab=VIN}
N 380 -1690 410 -1690 {
lab=VCM}
N 380 -1670 410 -1670 {
lab=VCM_1}
N 380 -1650 410 -1650 {
lab=agnd}
N 380 -1630 410 -1630 {
lab=CLKR[6]}
N 40 -1790 80 -1790 {
lab=vgateN}
N 40 -1770 80 -1770 {
lab=VIN}
N 380 -1790 410 -1790 {
lab=VCM}
N 380 -1770 410 -1770 {
lab=VCM_1}
N 380 -1750 410 -1750 {
lab=agnd}
N 380 -1730 410 -1730 {
lab=CLKR[6]}
N -400 -1690 -360 -1690 {
lab=vgateN}
N -400 -1670 -360 -1670 {
lab=VIN}
N -60 -1690 -30 -1690 {
lab=VCM}
N -60 -1670 -30 -1670 {
lab=VCM_1}
N -60 -1650 -30 -1650 {
lab=agnd}
N -60 -1630 -30 -1630 {
lab=CLKR[5]}
N -400 -1800 -360 -1800 {
lab=vgateN}
N -400 -1780 -360 -1780 {
lab=VIN}
N -60 -1800 -30 -1800 {
lab=VCM}
N -60 -1780 -30 -1780 {
lab=VCM_1}
N -60 -1760 -30 -1760 {
lab=agnd}
N -60 -1740 -30 -1740 {
lab=CLKR[5]}
N -400 -1890 -360 -1890 {
lab=vgateN}
N -400 -1870 -360 -1870 {
lab=VIN}
N -60 -1890 -30 -1890 {
lab=VCM}
N -60 -1870 -30 -1870 {
lab=VCM_1}
N -60 -1850 -30 -1850 {
lab=agnd}
N -60 -1830 -30 -1830 {
lab=CLKR[5]}
N -400 -2000 -360 -2000 {
lab=vgateN}
N -400 -1980 -360 -1980 {
lab=VIN}
N -60 -2000 -30 -2000 {
lab=VCM}
N -60 -1980 -30 -1980 {
lab=VCM_1}
N -60 -1960 -30 -1960 {
lab=agnd}
N -60 -1940 -30 -1940 {
lab=CLKR[5]}
N -840 -1690 -800 -1690 {
lab=vgateN}
N -840 -1670 -800 -1670 {
lab=VIN}
N -500 -1690 -470 -1690 {
lab=VCM}
N -500 -1670 -470 -1670 {
lab=VCM_1}
N -500 -1650 -470 -1650 {
lab=agnd}
N -500 -1630 -470 -1630 {
lab=CLKR[4]}
N -840 -1780 -800 -1780 {
lab=vgateN}
N -840 -1760 -800 -1760 {
lab=VIN}
N -500 -1780 -470 -1780 {
lab=VCM}
N -500 -1760 -470 -1760 {
lab=VCM_1}
N -500 -1740 -470 -1740 {
lab=agnd}
N -500 -1720 -470 -1720 {
lab=CLKR[4]}
N -840 -1870 -800 -1870 {
lab=vgateN}
N -840 -1850 -800 -1850 {
lab=VIN}
N -500 -1870 -470 -1870 {
lab=VCM}
N -500 -1850 -470 -1850 {
lab=VCM_1}
N -500 -1830 -470 -1830 {
lab=agnd}
N -500 -1810 -470 -1810 {
lab=CLKR[4]}
N -840 -1960 -800 -1960 {
lab=vgateN}
N -840 -1940 -800 -1940 {
lab=VIN}
N -500 -1960 -470 -1960 {
lab=VCM}
N -500 -1940 -470 -1940 {
lab=VCM_1}
N -500 -1920 -470 -1920 {
lab=agnd}
N -500 -1900 -470 -1900 {
lab=CLKR[4]}
N -840 -2060 -800 -2060 {
lab=vgateN}
N -840 -2040 -800 -2040 {
lab=VIN}
N -500 -2060 -470 -2060 {
lab=VCM}
N -500 -2040 -470 -2040 {
lab=VCM_1}
N -500 -2020 -470 -2020 {
lab=agnd}
N -500 -2000 -470 -2000 {
lab=CLKR[4]}
N -840 -2150 -800 -2150 {
lab=vgateN}
N -840 -2130 -800 -2130 {
lab=VIN}
N -500 -2150 -470 -2150 {
lab=VCM}
N -500 -2130 -470 -2130 {
lab=VCM_1}
N -500 -2110 -470 -2110 {
lab=agnd}
N -500 -2090 -470 -2090 {
lab=CLKR[4]}
N -840 -2240 -800 -2240 {
lab=vgateN}
N -840 -2220 -800 -2220 {
lab=VIN}
N -500 -2240 -470 -2240 {
lab=VCM}
N -500 -2220 -470 -2220 {
lab=VCM_1}
N -500 -2200 -470 -2200 {
lab=agnd}
N -500 -2180 -470 -2180 {
lab=CLKR[4]}
N -840 -2330 -800 -2330 {
lab=vgateN}
N -840 -2310 -800 -2310 {
lab=VIN}
N -500 -2330 -470 -2330 {
lab=VCM}
N -500 -2310 -470 -2310 {
lab=VCM_1}
N -500 -2290 -470 -2290 {
lab=agnd}
N -500 -2270 -470 -2270 {
lab=CLKR[4]}
N -1300 -1690 -1260 -1690 {
lab=vgateN}
N -1300 -1670 -1260 -1670 {
lab=VIN}
N -960 -1690 -930 -1690 {
lab=VCM}
N -960 -1670 -930 -1670 {
lab=VCM_1}
N -960 -1650 -930 -1650 {
lab=agnd}
N -960 -1630 -930 -1630 {
lab=CLKR[4]}
N -1300 -1790 -1260 -1790 {
lab=vgateN}
N -1300 -1770 -1260 -1770 {
lab=VIN}
N -960 -1790 -930 -1790 {
lab=VCM}
N -960 -1770 -930 -1770 {
lab=VCM_1}
N -960 -1750 -930 -1750 {
lab=agnd}
N -960 -1730 -930 -1730 {
lab=CLKR[4]}
N -1300 -1890 -1260 -1890 {
lab=vgateN}
N -1300 -1870 -1260 -1870 {
lab=VIN}
N -960 -1890 -930 -1890 {
lab=VCM}
N -960 -1870 -930 -1870 {
lab=VCM_1}
N -960 -1850 -930 -1850 {
lab=agnd}
N -960 -1830 -930 -1830 {
lab=CLKR[4]}
N -1300 -1990 -1260 -1990 {
lab=vgateN}
N -1300 -1970 -1260 -1970 {
lab=VIN}
N -960 -1990 -930 -1990 {
lab=VCM}
N -960 -1970 -930 -1970 {
lab=VCM_1}
N -960 -1950 -930 -1950 {
lab=agnd}
N -960 -1930 -930 -1930 {
lab=CLKR[4]}
N -1300 -2080 -1260 -2080 {
lab=vgateN}
N -1300 -2060 -1260 -2060 {
lab=VIN}
N -960 -2080 -930 -2080 {
lab=VCM}
N -960 -2060 -930 -2060 {
lab=VCM_1}
N -960 -2040 -930 -2040 {
lab=agnd}
N -960 -2020 -930 -2020 {
lab=CLKR[4]}
N -1300 -2180 -1260 -2180 {
lab=vgateN}
N -1300 -2160 -1260 -2160 {
lab=VIN}
N -960 -2180 -930 -2180 {
lab=VCM}
N -960 -2160 -930 -2160 {
lab=VCM_1}
N -960 -2140 -930 -2140 {
lab=agnd}
N -960 -2120 -930 -2120 {
lab=CLKR[4]}
N -1300 -2280 -1260 -2280 {
lab=vgateN}
N -1300 -2260 -1260 -2260 {
lab=VIN}
N -960 -2280 -930 -2280 {
lab=VCM}
N -960 -2260 -930 -2260 {
lab=VCM_1}
N -960 -2240 -930 -2240 {
lab=agnd}
N -960 -2220 -930 -2220 {
lab=CLKR[4]}
N -1300 -2380 -1260 -2380 {
lab=vgateN}
N -1300 -2360 -1260 -2360 {
lab=VIN}
N -960 -2380 -930 -2380 {
lab=VCM}
N -960 -2360 -930 -2360 {
lab=VCM_1}
N -960 -2340 -930 -2340 {
lab=agnd}
N -960 -2320 -930 -2320 {
lab=CLKR[4]}
N -1300 -2480 -1260 -2480 {
lab=vgateN}
N -1300 -2460 -1260 -2460 {
lab=VIN}
N -960 -2480 -930 -2480 {
lab=VCM}
N -960 -2460 -930 -2460 {
lab=VCM_1}
N -960 -2440 -930 -2440 {
lab=agnd}
N -960 -2420 -930 -2420 {
lab=CLKR[4]}
N -1300 -2580 -1260 -2580 {
lab=vgateN}
N -1300 -2560 -1260 -2560 {
lab=VIN}
N -960 -2580 -930 -2580 {
lab=VCM}
N -960 -2560 -930 -2560 {
lab=VCM_1}
N -960 -2540 -930 -2540 {
lab=agnd}
N -960 -2520 -930 -2520 {
lab=CLKR[4]}
N -1300 -2680 -1260 -2680 {
lab=vgateN}
N -1300 -2660 -1260 -2660 {
lab=VIN}
N -960 -2680 -930 -2680 {
lab=VCM}
N -960 -2660 -930 -2660 {
lab=VCM_1}
N -960 -2640 -930 -2640 {
lab=agnd}
N -960 -2620 -930 -2620 {
lab=CLKR[4]}
N -1300 -2780 -1260 -2780 {
lab=vgateN}
N -1300 -2760 -1260 -2760 {
lab=VIN}
N -960 -2780 -930 -2780 {
lab=VCM}
N -960 -2760 -930 -2760 {
lab=VCM_1}
N -960 -2740 -930 -2740 {
lab=agnd}
N -960 -2720 -930 -2720 {
lab=CLKR[4]}
N -1300 -2870 -1260 -2870 {
lab=vgateN}
N -1300 -2850 -1260 -2850 {
lab=VIN}
N -960 -2870 -930 -2870 {
lab=VCM}
N -960 -2850 -930 -2850 {
lab=VCM_1}
N -960 -2830 -930 -2830 {
lab=agnd}
N -960 -2810 -930 -2810 {
lab=CLKR[4]}
N -1300 -2970 -1260 -2970 {
lab=vgateN}
N -1300 -2950 -1260 -2950 {
lab=VIN}
N -960 -2970 -930 -2970 {
lab=VCM}
N -960 -2950 -930 -2950 {
lab=VCM_1}
N -960 -2930 -930 -2930 {
lab=agnd}
N -960 -2910 -930 -2910 {
lab=CLKR[4]}
N -1300 -3070 -1260 -3070 {
lab=vgateN}
N -1300 -3050 -1260 -3050 {
lab=VIN}
N -960 -3070 -930 -3070 {
lab=VCM}
N -960 -3050 -930 -3050 {
lab=VCM_1}
N -960 -3030 -930 -3030 {
lab=agnd}
N -960 -3010 -930 -3010 {
lab=CLKR[4]}
N -1300 -3170 -1260 -3170 {
lab=vgateN}
N -1300 -3150 -1260 -3150 {
lab=VIN}
N -960 -3170 -930 -3170 {
lab=VCM}
N -960 -3150 -930 -3150 {
lab=VCM_1}
N -960 -3130 -930 -3130 {
lab=agnd}
N -960 -3110 -930 -3110 {
lab=CLKR[4]}
N -1740 -1690 -1700 -1690 {
lab=vgateN}
N -1740 -1670 -1700 -1670 {
lab=VIN}
N -1400 -1690 -1370 -1690 {
lab=VCM}
N -1400 -1670 -1370 -1670 {
lab=VCM_1}
N -1400 -1650 -1370 -1650 {
lab=agnd}
N -1400 -1630 -1370 -1630 {
lab=CLKR[4]}
N -1740 -1790 -1700 -1790 {
lab=vgateN}
N -1740 -1770 -1700 -1770 {
lab=VIN}
N -1400 -1790 -1370 -1790 {
lab=VCM}
N -1400 -1770 -1370 -1770 {
lab=VCM_1}
N -1400 -1750 -1370 -1750 {
lab=agnd}
N -1400 -1730 -1370 -1730 {
lab=CLKR[4]}
N -1740 -1890 -1700 -1890 {
lab=vgateN}
N -1740 -1870 -1700 -1870 {
lab=VIN}
N -1400 -1890 -1370 -1890 {
lab=VCM}
N -1400 -1870 -1370 -1870 {
lab=VCM_1}
N -1400 -1850 -1370 -1850 {
lab=agnd}
N -1400 -1830 -1370 -1830 {
lab=CLKR[4]}
N -1740 -1990 -1700 -1990 {
lab=vgateN}
N -1740 -1970 -1700 -1970 {
lab=VIN}
N -1400 -1990 -1370 -1990 {
lab=VCM}
N -1400 -1970 -1370 -1970 {
lab=VCM_1}
N -1400 -1950 -1370 -1950 {
lab=agnd}
N -1400 -1930 -1370 -1930 {
lab=CLKR[4]}
N -1740 -2080 -1700 -2080 {
lab=vgateN}
N -1740 -2060 -1700 -2060 {
lab=VIN}
N -1400 -2080 -1370 -2080 {
lab=VCM}
N -1400 -2060 -1370 -2060 {
lab=VCM_1}
N -1400 -2040 -1370 -2040 {
lab=agnd}
N -1400 -2020 -1370 -2020 {
lab=CLKR[4]}
N -1740 -2180 -1700 -2180 {
lab=vgateN}
N -1740 -2160 -1700 -2160 {
lab=VIN}
N -1400 -2180 -1370 -2180 {
lab=VCM}
N -1400 -2160 -1370 -2160 {
lab=VCM_1}
N -1400 -2140 -1370 -2140 {
lab=agnd}
N -1400 -2120 -1370 -2120 {
lab=CLKR[4]}
N -1740 -2280 -1700 -2280 {
lab=vgateN}
N -1740 -2260 -1700 -2260 {
lab=VIN}
N -1400 -2280 -1370 -2280 {
lab=VCM}
N -1400 -2260 -1370 -2260 {
lab=VCM_1}
N -1400 -2240 -1370 -2240 {
lab=agnd}
N -1400 -2220 -1370 -2220 {
lab=CLKR[4]}
N -1740 -2380 -1700 -2380 {
lab=vgateN}
N -1740 -2360 -1700 -2360 {
lab=VIN}
N -1400 -2380 -1370 -2380 {
lab=VCM}
N -1400 -2360 -1370 -2360 {
lab=VCM_1}
N -1400 -2340 -1370 -2340 {
lab=agnd}
N -1400 -2320 -1370 -2320 {
lab=CLKR[4]}
N -1740 -2480 -1700 -2480 {
lab=vgateN}
N -1740 -2460 -1700 -2460 {
lab=VIN}
N -1400 -2480 -1370 -2480 {
lab=VCM}
N -1400 -2460 -1370 -2460 {
lab=VCM_1}
N -1400 -2440 -1370 -2440 {
lab=agnd}
N -1400 -2420 -1370 -2420 {
lab=CLKR[4]}
N -1740 -2580 -1700 -2580 {
lab=vgateN}
N -1740 -2560 -1700 -2560 {
lab=VIN}
N -1400 -2580 -1370 -2580 {
lab=VCM}
N -1400 -2560 -1370 -2560 {
lab=VCM_1}
N -1400 -2540 -1370 -2540 {
lab=agnd}
N -1400 -2520 -1370 -2520 {
lab=CLKR[4]}
N -1740 -2680 -1700 -2680 {
lab=vgateN}
N -1740 -2660 -1700 -2660 {
lab=VIN}
N -1400 -2680 -1370 -2680 {
lab=VCM}
N -1400 -2660 -1370 -2660 {
lab=VCM_1}
N -1400 -2640 -1370 -2640 {
lab=agnd}
N -1400 -2620 -1370 -2620 {
lab=CLKR[4]}
N -1740 -2780 -1700 -2780 {
lab=vgateN}
N -1740 -2760 -1700 -2760 {
lab=VIN}
N -1400 -2780 -1370 -2780 {
lab=VCM}
N -1400 -2760 -1370 -2760 {
lab=VCM_1}
N -1400 -2740 -1370 -2740 {
lab=agnd}
N -1400 -2720 -1370 -2720 {
lab=CLKR[4]}
N -1740 -2870 -1700 -2870 {
lab=vgateN}
N -1740 -2850 -1700 -2850 {
lab=VIN}
N -1400 -2870 -1370 -2870 {
lab=VCM}
N -1400 -2850 -1370 -2850 {
lab=VCM_1}
N -1400 -2830 -1370 -2830 {
lab=agnd}
N -1400 -2810 -1370 -2810 {
lab=CLKR[4]}
N -1740 -2970 -1700 -2970 {
lab=vgateN}
N -1740 -2950 -1700 -2950 {
lab=VIN}
N -1400 -2970 -1370 -2970 {
lab=VCM}
N -1400 -2950 -1370 -2950 {
lab=VCM_1}
N -1400 -2930 -1370 -2930 {
lab=agnd}
N -1400 -2910 -1370 -2910 {
lab=CLKR[4]}
N -1740 -3070 -1700 -3070 {
lab=vgateN}
N -1740 -3050 -1700 -3050 {
lab=VIN}
N -1400 -3070 -1370 -3070 {
lab=VCM}
N -1400 -3050 -1370 -3050 {
lab=VCM_1}
N -1400 -3030 -1370 -3030 {
lab=agnd}
N -1400 -3010 -1370 -3010 {
lab=CLKR[4]}
N -1740 -3170 -1700 -3170 {
lab=vgateN}
N -1740 -3150 -1700 -3150 {
lab=VIN}
N -1400 -3170 -1370 -3170 {
lab=VCM}
N -1400 -3150 -1370 -3150 {
lab=VCM_1}
N -1400 -3130 -1370 -3130 {
lab=agnd}
N -1400 -3110 -1370 -3110 {
lab=CLKR[4]}
N -1740 -3270 -1700 -3270 {
lab=vgateN}
N -1740 -3250 -1700 -3250 {
lab=VIN}
N -1400 -3270 -1370 -3270 {
lab=VCM}
N -1400 -3250 -1370 -3250 {
lab=VCM_1}
N -1400 -3230 -1370 -3230 {
lab=agnd}
N -1400 -3210 -1370 -3210 {
lab=CLKR[4]}
N -1740 -3370 -1700 -3370 {
lab=vgateN}
N -1740 -3350 -1700 -3350 {
lab=VIN}
N -1400 -3370 -1370 -3370 {
lab=VCM}
N -1400 -3350 -1370 -3350 {
lab=VCM_1}
N -1400 -3330 -1370 -3330 {
lab=agnd}
N -1400 -3310 -1370 -3310 {
lab=CLKR[4]}
N -1740 -3470 -1700 -3470 {
lab=vgateN}
N -1740 -3450 -1700 -3450 {
lab=VIN}
N -1400 -3470 -1370 -3470 {
lab=VCM}
N -1400 -3450 -1370 -3450 {
lab=VCM_1}
N -1400 -3430 -1370 -3430 {
lab=agnd}
N -1400 -3410 -1370 -3410 {
lab=CLKR[4]}
N -1740 -3570 -1700 -3570 {
lab=vgateN}
N -1740 -3550 -1700 -3550 {
lab=VIN}
N -1400 -3570 -1370 -3570 {
lab=VCM}
N -1400 -3550 -1370 -3550 {
lab=VCM_1}
N -1400 -3530 -1370 -3530 {
lab=agnd}
N -1400 -3510 -1370 -3510 {
lab=CLKR[4]}
N -1740 -3660 -1700 -3660 {
lab=vgateN}
N -1740 -3640 -1700 -3640 {
lab=VIN}
N -1400 -3660 -1370 -3660 {
lab=VCM}
N -1400 -3640 -1370 -3640 {
lab=VCM_1}
N -1400 -3620 -1370 -3620 {
lab=agnd}
N -1400 -3600 -1370 -3600 {
lab=CLKR[4]}
N -1740 -3760 -1700 -3760 {
lab=vgateN}
N -1740 -3740 -1700 -3740 {
lab=VIN}
N -1400 -3760 -1370 -3760 {
lab=VCM}
N -1400 -3740 -1370 -3740 {
lab=VCM_1}
N -1400 -3720 -1370 -3720 {
lab=agnd}
N -1400 -3700 -1370 -3700 {
lab=CLKR[4]}
N -1740 -3860 -1700 -3860 {
lab=vgateN}
N -1740 -3840 -1700 -3840 {
lab=VIN}
N -1400 -3860 -1370 -3860 {
lab=VCM}
N -1400 -3840 -1370 -3840 {
lab=VCM_1}
N -1400 -3820 -1370 -3820 {
lab=agnd}
N -1400 -3800 -1370 -3800 {
lab=CLKR[4]}
N -1740 -3960 -1700 -3960 {
lab=vgateN}
N -1740 -3940 -1700 -3940 {
lab=VIN}
N -1400 -3960 -1370 -3960 {
lab=VCM}
N -1400 -3940 -1370 -3940 {
lab=VCM_1}
N -1400 -3920 -1370 -3920 {
lab=agnd}
N -1400 -3900 -1370 -3900 {
lab=CLKR[4]}
N -1740 -4060 -1700 -4060 {
lab=vgateN}
N -1740 -4040 -1700 -4040 {
lab=VIN}
N -1400 -4060 -1370 -4060 {
lab=VCM}
N -1400 -4040 -1370 -4040 {
lab=VCM_1}
N -1400 -4020 -1370 -4020 {
lab=agnd}
N -1400 -4000 -1370 -4000 {
lab=CLKR[4]}
N -1740 -4160 -1700 -4160 {
lab=vgateN}
N -1740 -4140 -1700 -4140 {
lab=VIN}
N -1400 -4160 -1370 -4160 {
lab=VCM}
N -1400 -4140 -1370 -4140 {
lab=VCM_1}
N -1400 -4120 -1370 -4120 {
lab=agnd}
N -1400 -4100 -1370 -4100 {
lab=CLKR[4]}
N -1740 -4260 -1700 -4260 {
lab=vgateN}
N -1740 -4240 -1700 -4240 {
lab=VIN}
N -1400 -4260 -1370 -4260 {
lab=VCM}
N -1400 -4240 -1370 -4240 {
lab=VCM_1}
N -1400 -4220 -1370 -4220 {
lab=agnd}
N -1400 -4200 -1370 -4200 {
lab=CLKR[4]}
N -1740 -4360 -1700 -4360 {
lab=vgateN}
N -1740 -4340 -1700 -4340 {
lab=VIN}
N -1400 -4360 -1370 -4360 {
lab=VCM}
N -1400 -4340 -1370 -4340 {
lab=VCM_1}
N -1400 -4320 -1370 -4320 {
lab=agnd}
N -1400 -4300 -1370 -4300 {
lab=CLKR[4]}
N -1740 -4450 -1700 -4450 {
lab=vgateN}
N -1740 -4430 -1700 -4430 {
lab=VIN}
N -1400 -4450 -1370 -4450 {
lab=VCM}
N -1400 -4430 -1370 -4430 {
lab=VCM_1}
N -1400 -4410 -1370 -4410 {
lab=agnd}
N -1400 -4390 -1370 -4390 {
lab=CLKR[4]}
N -1740 -4550 -1700 -4550 {
lab=vgateN}
N -1740 -4530 -1700 -4530 {
lab=VIN}
N -1400 -4550 -1370 -4550 {
lab=VCM}
N -1400 -4530 -1370 -4530 {
lab=VCM_1}
N -1400 -4510 -1370 -4510 {
lab=agnd}
N -1400 -4490 -1370 -4490 {
lab=CLKR[4]}
N -1740 -4650 -1700 -4650 {
lab=vgateN}
N -1740 -4630 -1700 -4630 {
lab=VIN}
N -1400 -4650 -1370 -4650 {
lab=VCM}
N -1400 -4630 -1370 -4630 {
lab=VCM_1}
N -1400 -4610 -1370 -4610 {
lab=agnd}
N -1400 -4590 -1370 -4590 {
lab=CLKR[4]}
N -1740 -4750 -1700 -4750 {
lab=vgateN}
N -1740 -4730 -1700 -4730 {
lab=VIN}
N -1400 -4750 -1370 -4750 {
lab=VCM}
N -1400 -4730 -1370 -4730 {
lab=VCM_1}
N -1400 -4710 -1370 -4710 {
lab=agnd}
N -1400 -4690 -1370 -4690 {
lab=CLKR[4]}
N -2190 -1700 -2150 -1700 {
lab=vgateN}
N -2190 -1680 -2150 -1680 {
lab=VIN}
N -1850 -1700 -1820 -1700 {
lab=VCM}
N -1850 -1680 -1820 -1680 {
lab=VCM_1}
N -1850 -1660 -1820 -1660 {
lab=agnd}
N -1850 -1640 -1820 -1640 {
lab=CLKR[4]}
N -2190 -1800 -2150 -1800 {
lab=vgateN}
N -2190 -1780 -2150 -1780 {
lab=VIN}
N -1850 -1800 -1820 -1800 {
lab=VCM}
N -1850 -1780 -1820 -1780 {
lab=VCM_1}
N -1850 -1760 -1820 -1760 {
lab=agnd}
N -1850 -1740 -1820 -1740 {
lab=CLKR[4]}
N -2190 -1890 -2150 -1890 {
lab=vgateN}
N -2190 -1870 -2150 -1870 {
lab=VIN}
N -1850 -1890 -1820 -1890 {
lab=VCM}
N -1850 -1870 -1820 -1870 {
lab=VCM_1}
N -1850 -1850 -1820 -1850 {
lab=agnd}
N -1850 -1830 -1820 -1830 {
lab=CLKR[4]}
N -2190 -1990 -2150 -1990 {
lab=vgateN}
N -2190 -1970 -2150 -1970 {
lab=VIN}
N -1850 -1990 -1820 -1990 {
lab=VCM}
N -1850 -1970 -1820 -1970 {
lab=VCM_1}
N -1850 -1950 -1820 -1950 {
lab=agnd}
N -1850 -1930 -1820 -1930 {
lab=CLKR[4]}
N -2190 -2080 -2150 -2080 {
lab=vgateN}
N -2190 -2060 -2150 -2060 {
lab=VIN}
N -1850 -2080 -1820 -2080 {
lab=VCM}
N -1850 -2060 -1820 -2060 {
lab=VCM_1}
N -1850 -2040 -1820 -2040 {
lab=agnd}
N -1850 -2020 -1820 -2020 {
lab=CLKR[4]}
N -2190 -2180 -2150 -2180 {
lab=vgateN}
N -2190 -2160 -2150 -2160 {
lab=VIN}
N -1850 -2180 -1820 -2180 {
lab=VCM}
N -1850 -2160 -1820 -2160 {
lab=VCM_1}
N -1850 -2140 -1820 -2140 {
lab=agnd}
N -1850 -2120 -1820 -2120 {
lab=CLKR[4]}
N -2190 -2270 -2150 -2270 {
lab=vgateN}
N -2190 -2250 -2150 -2250 {
lab=VIN}
N -1850 -2270 -1820 -2270 {
lab=VCM}
N -1850 -2250 -1820 -2250 {
lab=VCM_1}
N -1850 -2230 -1820 -2230 {
lab=agnd}
N -1850 -2210 -1820 -2210 {
lab=CLKR[4]}
N -2190 -2370 -2150 -2370 {
lab=vgateN}
N -2190 -2350 -2150 -2350 {
lab=VIN}
N -1850 -2370 -1820 -2370 {
lab=VCM}
N -1850 -2350 -1820 -2350 {
lab=VCM_1}
N -1850 -2330 -1820 -2330 {
lab=agnd}
N -1850 -2310 -1820 -2310 {
lab=CLKR[4]}
N -2190 -2470 -2150 -2470 {
lab=vgateN}
N -2190 -2450 -2150 -2450 {
lab=VIN}
N -1850 -2470 -1820 -2470 {
lab=VCM}
N -1850 -2450 -1820 -2450 {
lab=VCM_1}
N -1850 -2430 -1820 -2430 {
lab=agnd}
N -1850 -2410 -1820 -2410 {
lab=CLKR[4]}
N -2190 -2570 -2150 -2570 {
lab=vgateN}
N -2190 -2550 -2150 -2550 {
lab=VIN}
N -1850 -2570 -1820 -2570 {
lab=VCM}
N -1850 -2550 -1820 -2550 {
lab=VCM_1}
N -1850 -2530 -1820 -2530 {
lab=agnd}
N -1850 -2510 -1820 -2510 {
lab=CLKR[4]}
N -2190 -2660 -2150 -2660 {
lab=vgateN}
N -2190 -2640 -2150 -2640 {
lab=VIN}
N -1850 -2660 -1820 -2660 {
lab=VCM}
N -1850 -2640 -1820 -2640 {
lab=VCM_1}
N -1850 -2620 -1820 -2620 {
lab=agnd}
N -1850 -2600 -1820 -2600 {
lab=CLKR[4]}
N -2190 -2760 -2150 -2760 {
lab=vgateN}
N -2190 -2740 -2150 -2740 {
lab=VIN}
N -1850 -2760 -1820 -2760 {
lab=VCM}
N -1850 -2740 -1820 -2740 {
lab=VCM_1}
N -1850 -2720 -1820 -2720 {
lab=agnd}
N -1850 -2700 -1820 -2700 {
lab=CLKR[4]}
N -2190 -2850 -2150 -2850 {
lab=vgateN}
N -2190 -2830 -2150 -2830 {
lab=VIN}
N -1850 -2850 -1820 -2850 {
lab=VCM}
N -1850 -2830 -1820 -2830 {
lab=VCM_1}
N -1850 -2810 -1820 -2810 {
lab=agnd}
N -1850 -2790 -1820 -2790 {
lab=CLKR[4]}
N -2190 -2950 -2150 -2950 {
lab=vgateN}
N -2190 -2930 -2150 -2930 {
lab=VIN}
N -1850 -2950 -1820 -2950 {
lab=VCM}
N -1850 -2930 -1820 -2930 {
lab=VCM_1}
N -1850 -2910 -1820 -2910 {
lab=agnd}
N -1850 -2890 -1820 -2890 {
lab=CLKR[4]}
N -2190 -3040 -2150 -3040 {
lab=vgateN}
N -2190 -3020 -2150 -3020 {
lab=VIN}
N -1850 -3040 -1820 -3040 {
lab=VCM}
N -1850 -3020 -1820 -3020 {
lab=VCM_1}
N -1850 -3000 -1820 -3000 {
lab=agnd}
N -1850 -2980 -1820 -2980 {
lab=CLKR[4]}
N -2190 -3140 -2150 -3140 {
lab=vgateN}
N -2190 -3120 -2150 -3120 {
lab=VIN}
N -1850 -3140 -1820 -3140 {
lab=VCM}
N -1850 -3120 -1820 -3120 {
lab=VCM_1}
N -1850 -3100 -1820 -3100 {
lab=agnd}
N -1850 -3080 -1820 -3080 {
lab=CLKR[4]}
N -2190 -3260 -2150 -3260 {
lab=vgateN}
N -2190 -3240 -2150 -3240 {
lab=VIN}
N -1850 -3260 -1820 -3260 {
lab=VCM}
N -1850 -3240 -1820 -3240 {
lab=VCM_1}
N -1850 -3220 -1820 -3220 {
lab=agnd}
N -1850 -3200 -1820 -3200 {
lab=CLKR[4]}
N -2190 -3360 -2150 -3360 {
lab=vgateN}
N -2190 -3340 -2150 -3340 {
lab=VIN}
N -1850 -3360 -1820 -3360 {
lab=VCM}
N -1850 -3340 -1820 -3340 {
lab=VCM_1}
N -1850 -3320 -1820 -3320 {
lab=agnd}
N -1850 -3300 -1820 -3300 {
lab=CLKR[4]}
N -2190 -3450 -2150 -3450 {
lab=vgateN}
N -2190 -3430 -2150 -3430 {
lab=VIN}
N -1850 -3450 -1820 -3450 {
lab=VCM}
N -1850 -3430 -1820 -3430 {
lab=VCM_1}
N -1850 -3410 -1820 -3410 {
lab=agnd}
N -1850 -3390 -1820 -3390 {
lab=CLKR[4]}
N -2190 -3550 -2150 -3550 {
lab=vgateN}
N -2190 -3530 -2150 -3530 {
lab=VIN}
N -1850 -3550 -1820 -3550 {
lab=VCM}
N -1850 -3530 -1820 -3530 {
lab=VCM_1}
N -1850 -3510 -1820 -3510 {
lab=agnd}
N -1850 -3490 -1820 -3490 {
lab=CLKR[4]}
N -2190 -3640 -2150 -3640 {
lab=vgateN}
N -2190 -3620 -2150 -3620 {
lab=VIN}
N -1850 -3640 -1820 -3640 {
lab=VCM}
N -1850 -3620 -1820 -3620 {
lab=VCM_1}
N -1850 -3600 -1820 -3600 {
lab=agnd}
N -1850 -3580 -1820 -3580 {
lab=CLKR[4]}
N -2190 -3740 -2150 -3740 {
lab=vgateN}
N -2190 -3720 -2150 -3720 {
lab=VIN}
N -1850 -3740 -1820 -3740 {
lab=VCM}
N -1850 -3720 -1820 -3720 {
lab=VCM_1}
N -1850 -3700 -1820 -3700 {
lab=agnd}
N -1850 -3680 -1820 -3680 {
lab=CLKR[4]}
N -2190 -3830 -2150 -3830 {
lab=vgateN}
N -2190 -3810 -2150 -3810 {
lab=VIN}
N -1850 -3830 -1820 -3830 {
lab=VCM}
N -1850 -3810 -1820 -3810 {
lab=VCM_1}
N -1850 -3790 -1820 -3790 {
lab=agnd}
N -1850 -3770 -1820 -3770 {
lab=CLKR[4]}
N -2190 -3930 -2150 -3930 {
lab=vgateN}
N -2190 -3910 -2150 -3910 {
lab=VIN}
N -1850 -3930 -1820 -3930 {
lab=VCM}
N -1850 -3910 -1820 -3910 {
lab=VCM_1}
N -1850 -3890 -1820 -3890 {
lab=agnd}
N -1850 -3870 -1820 -3870 {
lab=CLKR[4]}
N -2190 -4030 -2150 -4030 {
lab=vgateN}
N -2190 -4010 -2150 -4010 {
lab=VIN}
N -1850 -4030 -1820 -4030 {
lab=VCM}
N -1850 -4010 -1820 -4010 {
lab=VCM_1}
N -1850 -3990 -1820 -3990 {
lab=agnd}
N -1850 -3970 -1820 -3970 {
lab=CLKR[4]}
N -2190 -4130 -2150 -4130 {
lab=vgateN}
N -2190 -4110 -2150 -4110 {
lab=VIN}
N -1850 -4130 -1820 -4130 {
lab=VCM}
N -1850 -4110 -1820 -4110 {
lab=VCM_1}
N -1850 -4090 -1820 -4090 {
lab=agnd}
N -1850 -4070 -1820 -4070 {
lab=CLKR[4]}
N -2190 -4220 -2150 -4220 {
lab=vgateN}
N -2190 -4200 -2150 -4200 {
lab=VIN}
N -1850 -4220 -1820 -4220 {
lab=VCM}
N -1850 -4200 -1820 -4200 {
lab=VCM_1}
N -1850 -4180 -1820 -4180 {
lab=agnd}
N -1850 -4160 -1820 -4160 {
lab=CLKR[4]}
N -2190 -4320 -2150 -4320 {
lab=vgateN}
N -2190 -4300 -2150 -4300 {
lab=VIN}
N -1850 -4320 -1820 -4320 {
lab=VCM}
N -1850 -4300 -1820 -4300 {
lab=VCM_1}
N -1850 -4280 -1820 -4280 {
lab=agnd}
N -1850 -4260 -1820 -4260 {
lab=CLKR[4]}
N -2190 -4410 -2150 -4410 {
lab=vgateN}
N -2190 -4390 -2150 -4390 {
lab=VIN}
N -1850 -4410 -1820 -4410 {
lab=VCM}
N -1850 -4390 -1820 -4390 {
lab=VCM_1}
N -1850 -4370 -1820 -4370 {
lab=agnd}
N -1850 -4350 -1820 -4350 {
lab=CLKR[4]}
N -2190 -4510 -2150 -4510 {
lab=vgateN}
N -2190 -4490 -2150 -4490 {
lab=VIN}
N -1850 -4510 -1820 -4510 {
lab=VCM}
N -1850 -4490 -1820 -4490 {
lab=VCM_1}
N -1850 -4470 -1820 -4470 {
lab=agnd}
N -1850 -4450 -1820 -4450 {
lab=CLKR[4]}
N -2190 -4600 -2150 -4600 {
lab=vgateN}
N -2190 -4580 -2150 -4580 {
lab=VIN}
N -1850 -4600 -1820 -4600 {
lab=VCM}
N -1850 -4580 -1820 -4580 {
lab=VCM_1}
N -1850 -4560 -1820 -4560 {
lab=agnd}
N -1850 -4540 -1820 -4540 {
lab=CLKR[4]}
N -2190 -4700 -2150 -4700 {
lab=vgateN}
N -2190 -4680 -2150 -4680 {
lab=VIN}
N -1850 -4700 -1820 -4700 {
lab=VCM}
N -1850 -4680 -1820 -4680 {
lab=VCM_1}
N -1850 -4660 -1820 -4660 {
lab=agnd}
N -1850 -4640 -1820 -4640 {
lab=CLKR[4]}
N -2190 -4810 -2150 -4810 {
lab=vgateN}
N -2190 -4790 -2150 -4790 {
lab=VIN}
N -1850 -4810 -1820 -4810 {
lab=VCM}
N -1850 -4790 -1820 -4790 {
lab=VCM_1}
N -1850 -4770 -1820 -4770 {
lab=agnd}
N -1850 -4750 -1820 -4750 {
lab=CLKR[4]}
N -2190 -4910 -2150 -4910 {
lab=vgateN}
N -2190 -4890 -2150 -4890 {
lab=VIN}
N -1850 -4910 -1820 -4910 {
lab=VCM}
N -1850 -4890 -1820 -4890 {
lab=VCM_1}
N -1850 -4870 -1820 -4870 {
lab=agnd}
N -1850 -4850 -1820 -4850 {
lab=CLKR[4]}
N -2190 -5000 -2150 -5000 {
lab=vgateN}
N -2190 -4980 -2150 -4980 {
lab=VIN}
N -1850 -5000 -1820 -5000 {
lab=VCM}
N -1850 -4980 -1820 -4980 {
lab=VCM_1}
N -1850 -4960 -1820 -4960 {
lab=agnd}
N -1850 -4940 -1820 -4940 {
lab=CLKR[4]}
N -2190 -5100 -2150 -5100 {
lab=vgateN}
N -2190 -5080 -2150 -5080 {
lab=VIN}
N -1850 -5100 -1820 -5100 {
lab=VCM}
N -1850 -5080 -1820 -5080 {
lab=VCM_1}
N -1850 -5060 -1820 -5060 {
lab=agnd}
N -1850 -5040 -1820 -5040 {
lab=CLKR[4]}
N -2190 -5190 -2150 -5190 {
lab=vgateN}
N -2190 -5170 -2150 -5170 {
lab=VIN}
N -1850 -5190 -1820 -5190 {
lab=VCM}
N -1850 -5170 -1820 -5170 {
lab=VCM_1}
N -1850 -5150 -1820 -5150 {
lab=agnd}
N -1850 -5130 -1820 -5130 {
lab=CLKR[4]}
N -2190 -5290 -2150 -5290 {
lab=vgateN}
N -2190 -5270 -2150 -5270 {
lab=VIN}
N -1850 -5290 -1820 -5290 {
lab=VCM}
N -1850 -5270 -1820 -5270 {
lab=VCM_1}
N -1850 -5250 -1820 -5250 {
lab=agnd}
N -1850 -5230 -1820 -5230 {
lab=CLKR[4]}
N -2190 -5380 -2150 -5380 {
lab=vgateN}
N -2190 -5360 -2150 -5360 {
lab=VIN}
N -1850 -5380 -1820 -5380 {
lab=VCM}
N -1850 -5360 -1820 -5360 {
lab=VCM_1}
N -1850 -5340 -1820 -5340 {
lab=agnd}
N -1850 -5320 -1820 -5320 {
lab=CLKR[4]}
N -2190 -5480 -2150 -5480 {
lab=vgateN}
N -2190 -5460 -2150 -5460 {
lab=VIN}
N -1850 -5480 -1820 -5480 {
lab=VCM}
N -1850 -5460 -1820 -5460 {
lab=VCM_1}
N -1850 -5440 -1820 -5440 {
lab=agnd}
N -1850 -5420 -1820 -5420 {
lab=CLKR[4]}
N -2190 -5580 -2150 -5580 {
lab=vgateN}
N -2190 -5560 -2150 -5560 {
lab=VIN}
N -1850 -5580 -1820 -5580 {
lab=VCM}
N -1850 -5560 -1820 -5560 {
lab=VCM_1}
N -1850 -5540 -1820 -5540 {
lab=agnd}
N -1850 -5520 -1820 -5520 {
lab=CLKR[4]}
N -2190 -5680 -2150 -5680 {
lab=vgateN}
N -2190 -5660 -2150 -5660 {
lab=VIN}
N -1850 -5680 -1820 -5680 {
lab=VCM}
N -1850 -5660 -1820 -5660 {
lab=VCM_1}
N -1850 -5640 -1820 -5640 {
lab=agnd}
N -1850 -5620 -1820 -5620 {
lab=CLKR[4]}
N -2190 -5770 -2150 -5770 {
lab=vgateN}
N -2190 -5750 -2150 -5750 {
lab=VIN}
N -1850 -5770 -1820 -5770 {
lab=VCM}
N -1850 -5750 -1820 -5750 {
lab=VCM_1}
N -1850 -5730 -1820 -5730 {
lab=agnd}
N -1850 -5710 -1820 -5710 {
lab=CLKR[4]}
N -2190 -5870 -2150 -5870 {
lab=vgateN}
N -2190 -5850 -2150 -5850 {
lab=VIN}
N -1850 -5870 -1820 -5870 {
lab=VCM}
N -1850 -5850 -1820 -5850 {
lab=VCM_1}
N -1850 -5830 -1820 -5830 {
lab=agnd}
N -1850 -5810 -1820 -5810 {
lab=CLKR[4]}
N -2190 -5960 -2150 -5960 {
lab=vgateN}
N -2190 -5940 -2150 -5940 {
lab=VIN}
N -1850 -5960 -1820 -5960 {
lab=VCM}
N -1850 -5940 -1820 -5940 {
lab=VCM_1}
N -1850 -5920 -1820 -5920 {
lab=agnd}
N -1850 -5900 -1820 -5900 {
lab=CLKR[4]}
N -2190 -6060 -2150 -6060 {
lab=vgateN}
N -2190 -6040 -2150 -6040 {
lab=VIN}
N -1850 -6060 -1820 -6060 {
lab=VCM}
N -1850 -6040 -1820 -6040 {
lab=VCM_1}
N -1850 -6020 -1820 -6020 {
lab=agnd}
N -1850 -6000 -1820 -6000 {
lab=CLKR[4]}
N -2190 -6150 -2150 -6150 {
lab=vgateN}
N -2190 -6130 -2150 -6130 {
lab=VIN}
N -1850 -6150 -1820 -6150 {
lab=VCM}
N -1850 -6130 -1820 -6130 {
lab=VCM_1}
N -1850 -6110 -1820 -6110 {
lab=agnd}
N -1850 -6090 -1820 -6090 {
lab=CLKR[4]}
N -2190 -6250 -2150 -6250 {
lab=vgateN}
N -2190 -6230 -2150 -6230 {
lab=VIN}
N -1850 -6250 -1820 -6250 {
lab=VCM}
N -1850 -6230 -1820 -6230 {
lab=VCM_1}
N -1850 -6210 -1820 -6210 {
lab=agnd}
N -1850 -6190 -1820 -6190 {
lab=CLKR[4]}
N -2190 -6370 -2150 -6370 {
lab=vgateN}
N -2190 -6350 -2150 -6350 {
lab=VIN}
N -1850 -6370 -1820 -6370 {
lab=VCM}
N -1850 -6350 -1820 -6350 {
lab=VCM_1}
N -1850 -6330 -1820 -6330 {
lab=agnd}
N -1850 -6310 -1820 -6310 {
lab=CLKR[4]}
N -2190 -6470 -2150 -6470 {
lab=vgateN}
N -2190 -6450 -2150 -6450 {
lab=VIN}
N -1850 -6470 -1820 -6470 {
lab=VCM}
N -1850 -6450 -1820 -6450 {
lab=VCM_1}
N -1850 -6430 -1820 -6430 {
lab=agnd}
N -1850 -6410 -1820 -6410 {
lab=CLKR[4]}
N -2190 -6560 -2150 -6560 {
lab=vgateN}
N -2190 -6540 -2150 -6540 {
lab=VIN}
N -1850 -6560 -1820 -6560 {
lab=VCM}
N -1850 -6540 -1820 -6540 {
lab=VCM_1}
N -1850 -6520 -1820 -6520 {
lab=agnd}
N -1850 -6500 -1820 -6500 {
lab=CLKR[4]}
N -2190 -6660 -2150 -6660 {
lab=vgateN}
N -2190 -6640 -2150 -6640 {
lab=VIN}
N -1850 -6660 -1820 -6660 {
lab=VCM}
N -1850 -6640 -1820 -6640 {
lab=VCM_1}
N -1850 -6620 -1820 -6620 {
lab=agnd}
N -1850 -6600 -1820 -6600 {
lab=CLKR[4]}
N -2190 -6750 -2150 -6750 {
lab=vgateN}
N -2190 -6730 -2150 -6730 {
lab=VIN}
N -1850 -6750 -1820 -6750 {
lab=VCM}
N -1850 -6730 -1820 -6730 {
lab=VCM_1}
N -1850 -6710 -1820 -6710 {
lab=agnd}
N -1850 -6690 -1820 -6690 {
lab=CLKR[4]}
N -2190 -6850 -2150 -6850 {
lab=vgateN}
N -2190 -6830 -2150 -6830 {
lab=VIN}
N -1850 -6850 -1820 -6850 {
lab=VCM}
N -1850 -6830 -1820 -6830 {
lab=VCM_1}
N -1850 -6810 -1820 -6810 {
lab=agnd}
N -1850 -6790 -1820 -6790 {
lab=CLKR[4]}
N -2190 -6940 -2150 -6940 {
lab=vgateN}
N -2190 -6920 -2150 -6920 {
lab=VIN}
N -1850 -6940 -1820 -6940 {
lab=VCM}
N -1850 -6920 -1820 -6920 {
lab=VCM_1}
N -1850 -6900 -1820 -6900 {
lab=agnd}
N -1850 -6880 -1820 -6880 {
lab=CLKR[4]}
N -2190 -7040 -2150 -7040 {
lab=vgateN}
N -2190 -7020 -2150 -7020 {
lab=VIN}
N -1850 -7040 -1820 -7040 {
lab=VCM}
N -1850 -7020 -1820 -7020 {
lab=VCM_1}
N -1850 -7000 -1820 -7000 {
lab=agnd}
N -1850 -6980 -1820 -6980 {
lab=CLKR[4]}
N -2190 -7140 -2150 -7140 {
lab=vgateN}
N -2190 -7120 -2150 -7120 {
lab=VIN}
N -1850 -7140 -1820 -7140 {
lab=VCM}
N -1850 -7120 -1820 -7120 {
lab=VCM_1}
N -1850 -7100 -1820 -7100 {
lab=agnd}
N -1850 -7080 -1820 -7080 {
lab=CLKR[4]}
N -2190 -7240 -2150 -7240 {
lab=vgateN}
N -2190 -7220 -2150 -7220 {
lab=VIN}
N -1850 -7240 -1820 -7240 {
lab=VCM}
N -1850 -7220 -1820 -7220 {
lab=VCM_1}
N -1850 -7200 -1820 -7200 {
lab=agnd}
N -1850 -7180 -1820 -7180 {
lab=CLKR[4]}
N -2190 -7330 -2150 -7330 {
lab=vgateN}
N -2190 -7310 -2150 -7310 {
lab=VIN}
N -1850 -7330 -1820 -7330 {
lab=VCM}
N -1850 -7310 -1820 -7310 {
lab=VCM_1}
N -1850 -7290 -1820 -7290 {
lab=agnd}
N -1850 -7270 -1820 -7270 {
lab=CLKR[4]}
N -2190 -7430 -2150 -7430 {
lab=vgateN}
N -2190 -7410 -2150 -7410 {
lab=VIN}
N -1850 -7430 -1820 -7430 {
lab=VCM}
N -1850 -7410 -1820 -7410 {
lab=VCM_1}
N -1850 -7390 -1820 -7390 {
lab=agnd}
N -1850 -7370 -1820 -7370 {
lab=CLKR[4]}
N -2190 -7520 -2150 -7520 {
lab=vgateN}
N -2190 -7500 -2150 -7500 {
lab=VIN}
N -1850 -7520 -1820 -7520 {
lab=VCM}
N -1850 -7500 -1820 -7500 {
lab=VCM_1}
N -1850 -7480 -1820 -7480 {
lab=agnd}
N -1850 -7460 -1820 -7460 {
lab=CLKR[4]}
N -2190 -7620 -2150 -7620 {
lab=vgateN}
N -2190 -7600 -2150 -7600 {
lab=VIN}
N -1850 -7620 -1820 -7620 {
lab=VCM}
N -1850 -7600 -1820 -7600 {
lab=VCM_1}
N -1850 -7580 -1820 -7580 {
lab=agnd}
N -1850 -7560 -1820 -7560 {
lab=CLKR[4]}
N -2190 -7710 -2150 -7710 {
lab=vgateN}
N -2190 -7690 -2150 -7690 {
lab=VIN}
N -1850 -7710 -1820 -7710 {
lab=VCM}
N -1850 -7690 -1820 -7690 {
lab=VCM_1}
N -1850 -7670 -1820 -7670 {
lab=agnd}
N -1850 -7650 -1820 -7650 {
lab=CLKR[4]}
N -2190 -7810 -2150 -7810 {
lab=vgateN}
N -2190 -7790 -2150 -7790 {
lab=VIN}
N -1850 -7810 -1820 -7810 {
lab=VCM}
N -1850 -7790 -1820 -7790 {
lab=VCM_1}
N -1850 -7770 -1820 -7770 {
lab=agnd}
N -1850 -7750 -1820 -7750 {
lab=CLKR[4]}
N -2620 -1700 -2580 -1700 {
lab=vgateN}
N -2620 -1680 -2580 -1680 {
lab=VIN}
N -2280 -1700 -2250 -1700 {
lab=VCM}
N -2280 -1680 -2250 -1680 {
lab=VCM_1}
N -2280 -1660 -2250 -1660 {
lab=agnd}
N -2280 -1640 -2250 -1640 {
lab=CLKR[4]}
N -2620 -1800 -2580 -1800 {
lab=vgateN}
N -2620 -1780 -2580 -1780 {
lab=VIN}
N -2280 -1800 -2250 -1800 {
lab=VCM}
N -2280 -1780 -2250 -1780 {
lab=VCM_1}
N -2280 -1760 -2250 -1760 {
lab=agnd}
N -2280 -1740 -2250 -1740 {
lab=CLKR[4]}
N -2620 -1900 -2580 -1900 {
lab=vgateN}
N -2620 -1880 -2580 -1880 {
lab=VIN}
N -2280 -1900 -2250 -1900 {
lab=VCM}
N -2280 -1880 -2250 -1880 {
lab=VCM_1}
N -2280 -1860 -2250 -1860 {
lab=agnd}
N -2280 -1840 -2250 -1840 {
lab=CLKR[4]}
N -2620 -2000 -2580 -2000 {
lab=vgateN}
N -2620 -1980 -2580 -1980 {
lab=VIN}
N -2280 -2000 -2250 -2000 {
lab=VCM}
N -2280 -1980 -2250 -1980 {
lab=VCM_1}
N -2280 -1960 -2250 -1960 {
lab=agnd}
N -2280 -1940 -2250 -1940 {
lab=CLKR[4]}
N -2620 -2100 -2580 -2100 {
lab=vgateN}
N -2620 -2080 -2580 -2080 {
lab=VIN}
N -2280 -2100 -2250 -2100 {
lab=VCM}
N -2280 -2080 -2250 -2080 {
lab=VCM_1}
N -2280 -2060 -2250 -2060 {
lab=agnd}
N -2280 -2040 -2250 -2040 {
lab=CLKR[4]}
N -2620 -2200 -2580 -2200 {
lab=vgateN}
N -2620 -2180 -2580 -2180 {
lab=VIN}
N -2280 -2200 -2250 -2200 {
lab=VCM}
N -2280 -2180 -2250 -2180 {
lab=VCM_1}
N -2280 -2160 -2250 -2160 {
lab=agnd}
N -2280 -2140 -2250 -2140 {
lab=CLKR[4]}
N -2620 -2300 -2580 -2300 {
lab=vgateN}
N -2620 -2280 -2580 -2280 {
lab=VIN}
N -2280 -2300 -2250 -2300 {
lab=VCM}
N -2280 -2280 -2250 -2280 {
lab=VCM_1}
N -2280 -2260 -2250 -2260 {
lab=agnd}
N -2280 -2240 -2250 -2240 {
lab=CLKR[4]}
N -2620 -2400 -2580 -2400 {
lab=vgateN}
N -2620 -2380 -2580 -2380 {
lab=VIN}
N -2280 -2400 -2250 -2400 {
lab=VCM}
N -2280 -2380 -2250 -2380 {
lab=VCM_1}
N -2280 -2360 -2250 -2360 {
lab=agnd}
N -2280 -2340 -2250 -2340 {
lab=CLKR[4]}
N -2620 -2500 -2580 -2500 {
lab=vgateN}
N -2620 -2480 -2580 -2480 {
lab=VIN}
N -2280 -2500 -2250 -2500 {
lab=VCM}
N -2280 -2480 -2250 -2480 {
lab=VCM_1}
N -2280 -2460 -2250 -2460 {
lab=agnd}
N -2280 -2440 -2250 -2440 {
lab=CLKR[4]}
N -2620 -2600 -2580 -2600 {
lab=vgateN}
N -2620 -2580 -2580 -2580 {
lab=VIN}
N -2280 -2600 -2250 -2600 {
lab=VCM}
N -2280 -2580 -2250 -2580 {
lab=VCM_1}
N -2280 -2560 -2250 -2560 {
lab=agnd}
N -2280 -2540 -2250 -2540 {
lab=CLKR[4]}
N -2620 -2700 -2580 -2700 {
lab=vgateN}
N -2620 -2680 -2580 -2680 {
lab=VIN}
N -2280 -2700 -2250 -2700 {
lab=VCM}
N -2280 -2680 -2250 -2680 {
lab=VCM_1}
N -2280 -2660 -2250 -2660 {
lab=agnd}
N -2280 -2640 -2250 -2640 {
lab=CLKR[4]}
N -2620 -2800 -2580 -2800 {
lab=vgateN}
N -2620 -2780 -2580 -2780 {
lab=VIN}
N -2280 -2800 -2250 -2800 {
lab=VCM}
N -2280 -2780 -2250 -2780 {
lab=VCM_1}
N -2280 -2760 -2250 -2760 {
lab=agnd}
N -2280 -2740 -2250 -2740 {
lab=CLKR[4]}
N -2620 -2900 -2580 -2900 {
lab=vgateN}
N -2620 -2880 -2580 -2880 {
lab=VIN}
N -2280 -2900 -2250 -2900 {
lab=VCM}
N -2280 -2880 -2250 -2880 {
lab=VCM_1}
N -2280 -2860 -2250 -2860 {
lab=agnd}
N -2280 -2840 -2250 -2840 {
lab=CLKR[4]}
N -2620 -3000 -2580 -3000 {
lab=vgateN}
N -2620 -2980 -2580 -2980 {
lab=VIN}
N -2280 -3000 -2250 -3000 {
lab=VCM}
N -2280 -2980 -2250 -2980 {
lab=VCM_1}
N -2280 -2960 -2250 -2960 {
lab=agnd}
N -2280 -2940 -2250 -2940 {
lab=CLKR[4]}
N -2620 -3100 -2580 -3100 {
lab=vgateN}
N -2620 -3080 -2580 -3080 {
lab=VIN}
N -2280 -3100 -2250 -3100 {
lab=VCM}
N -2280 -3080 -2250 -3080 {
lab=VCM_1}
N -2280 -3060 -2250 -3060 {
lab=agnd}
N -2280 -3040 -2250 -3040 {
lab=CLKR[4]}
N -2620 -3200 -2580 -3200 {
lab=vgateN}
N -2620 -3180 -2580 -3180 {
lab=VIN}
N -2280 -3200 -2250 -3200 {
lab=VCM}
N -2280 -3180 -2250 -3180 {
lab=VCM_1}
N -2280 -3160 -2250 -3160 {
lab=agnd}
N -2280 -3140 -2250 -3140 {
lab=CLKR[4]}
N -2620 -3310 -2580 -3310 {
lab=vgateN}
N -2620 -3290 -2580 -3290 {
lab=VIN}
N -2280 -3310 -2250 -3310 {
lab=VCM}
N -2280 -3290 -2250 -3290 {
lab=VCM_1}
N -2280 -3270 -2250 -3270 {
lab=agnd}
N -2280 -3250 -2250 -3250 {
lab=CLKR[4]}
N -2620 -3410 -2580 -3410 {
lab=vgateN}
N -2620 -3390 -2580 -3390 {
lab=VIN}
N -2280 -3410 -2250 -3410 {
lab=VCM}
N -2280 -3390 -2250 -3390 {
lab=VCM_1}
N -2280 -3370 -2250 -3370 {
lab=agnd}
N -2280 -3350 -2250 -3350 {
lab=CLKR[4]}
N -2620 -3510 -2580 -3510 {
lab=vgateN}
N -2620 -3490 -2580 -3490 {
lab=VIN}
N -2280 -3510 -2250 -3510 {
lab=VCM}
N -2280 -3490 -2250 -3490 {
lab=VCM_1}
N -2280 -3470 -2250 -3470 {
lab=agnd}
N -2280 -3450 -2250 -3450 {
lab=CLKR[4]}
N -2620 -3610 -2580 -3610 {
lab=vgateN}
N -2620 -3590 -2580 -3590 {
lab=VIN}
N -2280 -3610 -2250 -3610 {
lab=VCM}
N -2280 -3590 -2250 -3590 {
lab=VCM_1}
N -2280 -3570 -2250 -3570 {
lab=agnd}
N -2280 -3550 -2250 -3550 {
lab=CLKR[4]}
N -2620 -3710 -2580 -3710 {
lab=vgateN}
N -2620 -3690 -2580 -3690 {
lab=VIN}
N -2280 -3710 -2250 -3710 {
lab=VCM}
N -2280 -3690 -2250 -3690 {
lab=VCM_1}
N -2280 -3670 -2250 -3670 {
lab=agnd}
N -2280 -3650 -2250 -3650 {
lab=CLKR[4]}
N -2620 -3810 -2580 -3810 {
lab=vgateN}
N -2620 -3790 -2580 -3790 {
lab=VIN}
N -2280 -3810 -2250 -3810 {
lab=VCM}
N -2280 -3790 -2250 -3790 {
lab=VCM_1}
N -2280 -3770 -2250 -3770 {
lab=agnd}
N -2280 -3750 -2250 -3750 {
lab=CLKR[4]}
N -2620 -3910 -2580 -3910 {
lab=vgateN}
N -2620 -3890 -2580 -3890 {
lab=VIN}
N -2280 -3910 -2250 -3910 {
lab=VCM}
N -2280 -3890 -2250 -3890 {
lab=VCM_1}
N -2280 -3870 -2250 -3870 {
lab=agnd}
N -2280 -3850 -2250 -3850 {
lab=CLKR[4]}
N -2620 -4010 -2580 -4010 {
lab=vgateN}
N -2620 -3990 -2580 -3990 {
lab=VIN}
N -2280 -4010 -2250 -4010 {
lab=VCM}
N -2280 -3990 -2250 -3990 {
lab=VCM_1}
N -2280 -3970 -2250 -3970 {
lab=agnd}
N -2280 -3950 -2250 -3950 {
lab=CLKR[4]}
N -2620 -4110 -2580 -4110 {
lab=vgateN}
N -2620 -4090 -2580 -4090 {
lab=VIN}
N -2280 -4110 -2250 -4110 {
lab=VCM}
N -2280 -4090 -2250 -4090 {
lab=VCM_1}
N -2280 -4070 -2250 -4070 {
lab=agnd}
N -2280 -4050 -2250 -4050 {
lab=CLKR[4]}
N -2620 -4210 -2580 -4210 {
lab=vgateN}
N -2620 -4190 -2580 -4190 {
lab=VIN}
N -2280 -4210 -2250 -4210 {
lab=VCM}
N -2280 -4190 -2250 -4190 {
lab=VCM_1}
N -2280 -4170 -2250 -4170 {
lab=agnd}
N -2280 -4150 -2250 -4150 {
lab=CLKR[4]}
N -2620 -4310 -2580 -4310 {
lab=vgateN}
N -2620 -4290 -2580 -4290 {
lab=VIN}
N -2280 -4310 -2250 -4310 {
lab=VCM}
N -2280 -4290 -2250 -4290 {
lab=VCM_1}
N -2280 -4270 -2250 -4270 {
lab=agnd}
N -2280 -4250 -2250 -4250 {
lab=CLKR[4]}
N -2620 -4410 -2580 -4410 {
lab=vgateN}
N -2620 -4390 -2580 -4390 {
lab=VIN}
N -2280 -4410 -2250 -4410 {
lab=VCM}
N -2280 -4390 -2250 -4390 {
lab=VCM_1}
N -2280 -4370 -2250 -4370 {
lab=agnd}
N -2280 -4350 -2250 -4350 {
lab=CLKR[4]}
N -2620 -4510 -2580 -4510 {
lab=vgateN}
N -2620 -4490 -2580 -4490 {
lab=VIN}
N -2280 -4510 -2250 -4510 {
lab=VCM}
N -2280 -4490 -2250 -4490 {
lab=VCM_1}
N -2280 -4470 -2250 -4470 {
lab=agnd}
N -2280 -4450 -2250 -4450 {
lab=CLKR[4]}
N -2620 -4610 -2580 -4610 {
lab=vgateN}
N -2620 -4590 -2580 -4590 {
lab=VIN}
N -2280 -4610 -2250 -4610 {
lab=VCM}
N -2280 -4590 -2250 -4590 {
lab=VCM_1}
N -2280 -4570 -2250 -4570 {
lab=agnd}
N -2280 -4550 -2250 -4550 {
lab=CLKR[4]}
N -2620 -4710 -2580 -4710 {
lab=vgateN}
N -2620 -4690 -2580 -4690 {
lab=VIN}
N -2280 -4710 -2250 -4710 {
lab=VCM}
N -2280 -4690 -2250 -4690 {
lab=VCM_1}
N -2280 -4670 -2250 -4670 {
lab=agnd}
N -2280 -4650 -2250 -4650 {
lab=CLKR[4]}
N -2620 -4810 -2580 -4810 {
lab=vgateN}
N -2620 -4790 -2580 -4790 {
lab=VIN}
N -2280 -4810 -2250 -4810 {
lab=VCM}
N -2280 -4790 -2250 -4790 {
lab=VCM_1}
N -2280 -4770 -2250 -4770 {
lab=agnd}
N -2280 -4750 -2250 -4750 {
lab=CLKR[4]}
N -2620 -4920 -2580 -4920 {
lab=vgateN}
N -2620 -4900 -2580 -4900 {
lab=VIN}
N -2280 -4920 -2250 -4920 {
lab=VCM}
N -2280 -4900 -2250 -4900 {
lab=VCM_1}
N -2280 -4880 -2250 -4880 {
lab=agnd}
N -2280 -4860 -2250 -4860 {
lab=CLKR[4]}
N -2620 -5020 -2580 -5020 {
lab=vgateN}
N -2620 -5000 -2580 -5000 {
lab=VIN}
N -2280 -5020 -2250 -5020 {
lab=VCM}
N -2280 -5000 -2250 -5000 {
lab=VCM_1}
N -2280 -4980 -2250 -4980 {
lab=agnd}
N -2280 -4960 -2250 -4960 {
lab=CLKR[4]}
N -2620 -5120 -2580 -5120 {
lab=vgateN}
N -2620 -5100 -2580 -5100 {
lab=VIN}
N -2280 -5120 -2250 -5120 {
lab=VCM}
N -2280 -5100 -2250 -5100 {
lab=VCM_1}
N -2280 -5080 -2250 -5080 {
lab=agnd}
N -2280 -5060 -2250 -5060 {
lab=CLKR[4]}
N -2620 -5220 -2580 -5220 {
lab=vgateN}
N -2620 -5200 -2580 -5200 {
lab=VIN}
N -2280 -5220 -2250 -5220 {
lab=VCM}
N -2280 -5200 -2250 -5200 {
lab=VCM_1}
N -2280 -5180 -2250 -5180 {
lab=agnd}
N -2280 -5160 -2250 -5160 {
lab=CLKR[4]}
N -2620 -5320 -2580 -5320 {
lab=vgateN}
N -2620 -5300 -2580 -5300 {
lab=VIN}
N -2280 -5320 -2250 -5320 {
lab=VCM}
N -2280 -5300 -2250 -5300 {
lab=VCM_1}
N -2280 -5280 -2250 -5280 {
lab=agnd}
N -2280 -5260 -2250 -5260 {
lab=CLKR[4]}
N -2620 -5420 -2580 -5420 {
lab=vgateN}
N -2620 -5400 -2580 -5400 {
lab=VIN}
N -2280 -5420 -2250 -5420 {
lab=VCM}
N -2280 -5400 -2250 -5400 {
lab=VCM_1}
N -2280 -5380 -2250 -5380 {
lab=agnd}
N -2280 -5360 -2250 -5360 {
lab=CLKR[4]}
N -2620 -5520 -2580 -5520 {
lab=vgateN}
N -2620 -5500 -2580 -5500 {
lab=VIN}
N -2280 -5520 -2250 -5520 {
lab=VCM}
N -2280 -5500 -2250 -5500 {
lab=VCM_1}
N -2280 -5480 -2250 -5480 {
lab=agnd}
N -2280 -5460 -2250 -5460 {
lab=CLKR[4]}
N -2620 -5620 -2580 -5620 {
lab=vgateN}
N -2620 -5600 -2580 -5600 {
lab=VIN}
N -2280 -5620 -2250 -5620 {
lab=VCM}
N -2280 -5600 -2250 -5600 {
lab=VCM_1}
N -2280 -5580 -2250 -5580 {
lab=agnd}
N -2280 -5560 -2250 -5560 {
lab=CLKR[4]}
N -2620 -5720 -2580 -5720 {
lab=vgateN}
N -2620 -5700 -2580 -5700 {
lab=VIN}
N -2280 -5720 -2250 -5720 {
lab=VCM}
N -2280 -5700 -2250 -5700 {
lab=VCM_1}
N -2280 -5680 -2250 -5680 {
lab=agnd}
N -2280 -5660 -2250 -5660 {
lab=CLKR[4]}
N -2620 -5820 -2580 -5820 {
lab=vgateN}
N -2620 -5800 -2580 -5800 {
lab=VIN}
N -2280 -5820 -2250 -5820 {
lab=VCM}
N -2280 -5800 -2250 -5800 {
lab=VCM_1}
N -2280 -5780 -2250 -5780 {
lab=agnd}
N -2280 -5760 -2250 -5760 {
lab=CLKR[4]}
N -2620 -5920 -2580 -5920 {
lab=vgateN}
N -2620 -5900 -2580 -5900 {
lab=VIN}
N -2280 -5920 -2250 -5920 {
lab=VCM}
N -2280 -5900 -2250 -5900 {
lab=VCM_1}
N -2280 -5880 -2250 -5880 {
lab=agnd}
N -2280 -5860 -2250 -5860 {
lab=CLKR[4]}
N -2620 -6020 -2580 -6020 {
lab=vgateN}
N -2620 -6000 -2580 -6000 {
lab=VIN}
N -2280 -6020 -2250 -6020 {
lab=VCM}
N -2280 -6000 -2250 -6000 {
lab=VCM_1}
N -2280 -5980 -2250 -5980 {
lab=agnd}
N -2280 -5960 -2250 -5960 {
lab=CLKR[4]}
N -2620 -6120 -2580 -6120 {
lab=vgateN}
N -2620 -6100 -2580 -6100 {
lab=VIN}
N -2280 -6120 -2250 -6120 {
lab=VCM}
N -2280 -6100 -2250 -6100 {
lab=VCM_1}
N -2280 -6080 -2250 -6080 {
lab=agnd}
N -2280 -6060 -2250 -6060 {
lab=CLKR[4]}
N -2620 -6220 -2580 -6220 {
lab=vgateN}
N -2620 -6200 -2580 -6200 {
lab=VIN}
N -2280 -6220 -2250 -6220 {
lab=VCM}
N -2280 -6200 -2250 -6200 {
lab=VCM_1}
N -2280 -6180 -2250 -6180 {
lab=agnd}
N -2280 -6160 -2250 -6160 {
lab=CLKR[4]}
N -2620 -6320 -2580 -6320 {
lab=vgateN}
N -2620 -6300 -2580 -6300 {
lab=VIN}
N -2280 -6320 -2250 -6320 {
lab=VCM}
N -2280 -6300 -2250 -6300 {
lab=VCM_1}
N -2280 -6280 -2250 -6280 {
lab=agnd}
N -2280 -6260 -2250 -6260 {
lab=CLKR[4]}
N -2620 -6420 -2580 -6420 {
lab=vgateN}
N -2620 -6400 -2580 -6400 {
lab=VIN}
N -2280 -6420 -2250 -6420 {
lab=VCM}
N -2280 -6400 -2250 -6400 {
lab=VCM_1}
N -2280 -6380 -2250 -6380 {
lab=agnd}
N -2280 -6360 -2250 -6360 {
lab=CLKR[4]}
N -2620 -6530 -2580 -6530 {
lab=vgateN}
N -2620 -6510 -2580 -6510 {
lab=VIN}
N -2280 -6530 -2250 -6530 {
lab=VCM}
N -2280 -6510 -2250 -6510 {
lab=VCM_1}
N -2280 -6490 -2250 -6490 {
lab=agnd}
N -2280 -6470 -2250 -6470 {
lab=CLKR[4]}
N -2620 -6630 -2580 -6630 {
lab=vgateN}
N -2620 -6610 -2580 -6610 {
lab=VIN}
N -2280 -6630 -2250 -6630 {
lab=VCM}
N -2280 -6610 -2250 -6610 {
lab=VCM_1}
N -2280 -6590 -2250 -6590 {
lab=agnd}
N -2280 -6570 -2250 -6570 {
lab=CLKR[4]}
N -2620 -6730 -2580 -6730 {
lab=vgateN}
N -2620 -6710 -2580 -6710 {
lab=VIN}
N -2280 -6730 -2250 -6730 {
lab=VCM}
N -2280 -6710 -2250 -6710 {
lab=VCM_1}
N -2280 -6690 -2250 -6690 {
lab=agnd}
N -2280 -6670 -2250 -6670 {
lab=CLKR[4]}
N -2620 -6830 -2580 -6830 {
lab=vgateN}
N -2620 -6810 -2580 -6810 {
lab=VIN}
N -2280 -6830 -2250 -6830 {
lab=VCM}
N -2280 -6810 -2250 -6810 {
lab=VCM_1}
N -2280 -6790 -2250 -6790 {
lab=agnd}
N -2280 -6770 -2250 -6770 {
lab=CLKR[4]}
N -2620 -6930 -2580 -6930 {
lab=vgateN}
N -2620 -6910 -2580 -6910 {
lab=VIN}
N -2280 -6930 -2250 -6930 {
lab=VCM}
N -2280 -6910 -2250 -6910 {
lab=VCM_1}
N -2280 -6890 -2250 -6890 {
lab=agnd}
N -2280 -6870 -2250 -6870 {
lab=CLKR[4]}
N -2620 -7030 -2580 -7030 {
lab=vgateN}
N -2620 -7010 -2580 -7010 {
lab=VIN}
N -2280 -7030 -2250 -7030 {
lab=VCM}
N -2280 -7010 -2250 -7010 {
lab=VCM_1}
N -2280 -6990 -2250 -6990 {
lab=agnd}
N -2280 -6970 -2250 -6970 {
lab=CLKR[4]}
N -2620 -7130 -2580 -7130 {
lab=vgateN}
N -2620 -7110 -2580 -7110 {
lab=VIN}
N -2280 -7130 -2250 -7130 {
lab=VCM}
N -2280 -7110 -2250 -7110 {
lab=VCM_1}
N -2280 -7090 -2250 -7090 {
lab=agnd}
N -2280 -7070 -2250 -7070 {
lab=CLKR[4]}
N -2620 -7230 -2580 -7230 {
lab=vgateN}
N -2620 -7210 -2580 -7210 {
lab=VIN}
N -2280 -7230 -2250 -7230 {
lab=VCM}
N -2280 -7210 -2250 -7210 {
lab=VCM_1}
N -2280 -7190 -2250 -7190 {
lab=agnd}
N -2280 -7170 -2250 -7170 {
lab=CLKR[4]}
N -2620 -7330 -2580 -7330 {
lab=vgateN}
N -2620 -7310 -2580 -7310 {
lab=VIN}
N -2280 -7330 -2250 -7330 {
lab=VCM}
N -2280 -7310 -2250 -7310 {
lab=VCM_1}
N -2280 -7290 -2250 -7290 {
lab=agnd}
N -2280 -7270 -2250 -7270 {
lab=CLKR[4]}
N -2620 -7430 -2580 -7430 {
lab=vgateN}
N -2620 -7410 -2580 -7410 {
lab=VIN}
N -2280 -7430 -2250 -7430 {
lab=VCM}
N -2280 -7410 -2250 -7410 {
lab=VCM_1}
N -2280 -7390 -2250 -7390 {
lab=agnd}
N -2280 -7370 -2250 -7370 {
lab=CLKR[4]}
N -2620 -7530 -2580 -7530 {
lab=vgateN}
N -2620 -7510 -2580 -7510 {
lab=VIN}
N -2280 -7530 -2250 -7530 {
lab=VCM}
N -2280 -7510 -2250 -7510 {
lab=VCM_1}
N -2280 -7490 -2250 -7490 {
lab=agnd}
N -2280 -7470 -2250 -7470 {
lab=CLKR[4]}
N -2620 -7630 -2580 -7630 {
lab=vgateN}
N -2620 -7610 -2580 -7610 {
lab=VIN}
N -2280 -7630 -2250 -7630 {
lab=VCM}
N -2280 -7610 -2250 -7610 {
lab=VCM_1}
N -2280 -7590 -2250 -7590 {
lab=agnd}
N -2280 -7570 -2250 -7570 {
lab=CLKR[4]}
N -2620 -7730 -2580 -7730 {
lab=vgateN}
N -2620 -7710 -2580 -7710 {
lab=VIN}
N -2280 -7730 -2250 -7730 {
lab=VCM}
N -2280 -7710 -2250 -7710 {
lab=VCM_1}
N -2280 -7690 -2250 -7690 {
lab=agnd}
N -2280 -7670 -2250 -7670 {
lab=CLKR[4]}
N -2620 -7830 -2580 -7830 {
lab=vgateN}
N -2620 -7810 -2580 -7810 {
lab=VIN}
N -2280 -7830 -2250 -7830 {
lab=VCM}
N -2280 -7810 -2250 -7810 {
lab=VCM_1}
N -2280 -7790 -2250 -7790 {
lab=agnd}
N -2280 -7770 -2250 -7770 {
lab=CLKR[4]}
N -2620 -7930 -2580 -7930 {
lab=vgateN}
N -2620 -7910 -2580 -7910 {
lab=VIN}
N -2280 -7930 -2250 -7930 {
lab=VCM}
N -2280 -7910 -2250 -7910 {
lab=VCM_1}
N -2280 -7890 -2250 -7890 {
lab=agnd}
N -2280 -7870 -2250 -7870 {
lab=CLKR[4]}
N -2620 -8030 -2580 -8030 {
lab=vgateN}
N -2620 -8010 -2580 -8010 {
lab=VIN}
N -2280 -8030 -2250 -8030 {
lab=VCM}
N -2280 -8010 -2250 -8010 {
lab=VCM_1}
N -2280 -7990 -2250 -7990 {
lab=agnd}
N -2280 -7970 -2250 -7970 {
lab=CLKR[4]}
N -2610 -8160 -2570 -8160 {
lab=vgateN}
N -2610 -8140 -2570 -8140 {
lab=VIN}
N -2270 -8160 -2240 -8160 {
lab=VCM}
N -2270 -8140 -2240 -8140 {
lab=VCM_1}
N -2270 -8120 -2240 -8120 {
lab=agnd}
N -2270 -8100 -2240 -8100 {
lab=CLKR[4]}
N -2610 -8260 -2570 -8260 {
lab=vgateN}
N -2610 -8240 -2570 -8240 {
lab=VIN}
N -2270 -8260 -2240 -8260 {
lab=VCM}
N -2270 -8240 -2240 -8240 {
lab=VCM_1}
N -2270 -8220 -2240 -8220 {
lab=agnd}
N -2270 -8200 -2240 -8200 {
lab=CLKR[4]}
N -2610 -8360 -2570 -8360 {
lab=vgateN}
N -2610 -8340 -2570 -8340 {
lab=VIN}
N -2270 -8360 -2240 -8360 {
lab=VCM}
N -2270 -8340 -2240 -8340 {
lab=VCM_1}
N -2270 -8320 -2240 -8320 {
lab=agnd}
N -2270 -8300 -2240 -8300 {
lab=CLKR[4]}
N -2610 -8460 -2570 -8460 {
lab=vgateN}
N -2610 -8440 -2570 -8440 {
lab=VIN}
N -2270 -8460 -2240 -8460 {
lab=VCM}
N -2270 -8440 -2240 -8440 {
lab=VCM_1}
N -2270 -8420 -2240 -8420 {
lab=agnd}
N -2270 -8400 -2240 -8400 {
lab=CLKR[4]}
N -2610 -8560 -2570 -8560 {
lab=vgateN}
N -2610 -8540 -2570 -8540 {
lab=VIN}
N -2270 -8560 -2240 -8560 {
lab=VCM}
N -2270 -8540 -2240 -8540 {
lab=VCM_1}
N -2270 -8520 -2240 -8520 {
lab=agnd}
N -2270 -8500 -2240 -8500 {
lab=CLKR[4]}
N -2610 -8660 -2570 -8660 {
lab=vgateN}
N -2610 -8640 -2570 -8640 {
lab=VIN}
N -2270 -8660 -2240 -8660 {
lab=VCM}
N -2270 -8640 -2240 -8640 {
lab=VCM_1}
N -2270 -8620 -2240 -8620 {
lab=agnd}
N -2270 -8600 -2240 -8600 {
lab=CLKR[4]}
N -2610 -8760 -2570 -8760 {
lab=vgateN}
N -2610 -8740 -2570 -8740 {
lab=VIN}
N -2270 -8760 -2240 -8760 {
lab=VCM}
N -2270 -8740 -2240 -8740 {
lab=VCM_1}
N -2270 -8720 -2240 -8720 {
lab=agnd}
N -2270 -8700 -2240 -8700 {
lab=CLKR[4]}
N -2610 -8860 -2570 -8860 {
lab=vgateN}
N -2610 -8840 -2570 -8840 {
lab=VIN}
N -2270 -8860 -2240 -8860 {
lab=VCM}
N -2270 -8840 -2240 -8840 {
lab=VCM_1}
N -2270 -8820 -2240 -8820 {
lab=agnd}
N -2270 -8800 -2240 -8800 {
lab=CLKR[4]}
N -2610 -8960 -2570 -8960 {
lab=vgateN}
N -2610 -8940 -2570 -8940 {
lab=VIN}
N -2270 -8960 -2240 -8960 {
lab=VCM}
N -2270 -8940 -2240 -8940 {
lab=VCM_1}
N -2270 -8920 -2240 -8920 {
lab=agnd}
N -2270 -8900 -2240 -8900 {
lab=CLKR[4]}
N -2610 -9060 -2570 -9060 {
lab=vgateN}
N -2610 -9040 -2570 -9040 {
lab=VIN}
N -2270 -9060 -2240 -9060 {
lab=VCM}
N -2270 -9040 -2240 -9040 {
lab=VCM_1}
N -2270 -9020 -2240 -9020 {
lab=agnd}
N -2270 -9000 -2240 -9000 {
lab=CLKR[4]}
N -2610 -9160 -2570 -9160 {
lab=vgateN}
N -2610 -9140 -2570 -9140 {
lab=VIN}
N -2270 -9160 -2240 -9160 {
lab=VCM}
N -2270 -9140 -2240 -9140 {
lab=VCM_1}
N -2270 -9120 -2240 -9120 {
lab=agnd}
N -2270 -9100 -2240 -9100 {
lab=CLKR[4]}
N -2610 -9260 -2570 -9260 {
lab=vgateN}
N -2610 -9240 -2570 -9240 {
lab=VIN}
N -2270 -9260 -2240 -9260 {
lab=VCM}
N -2270 -9240 -2240 -9240 {
lab=VCM_1}
N -2270 -9220 -2240 -9220 {
lab=agnd}
N -2270 -9200 -2240 -9200 {
lab=CLKR[4]}
N -2610 -9360 -2570 -9360 {
lab=vgateN}
N -2610 -9340 -2570 -9340 {
lab=VIN}
N -2270 -9360 -2240 -9360 {
lab=VCM}
N -2270 -9340 -2240 -9340 {
lab=VCM_1}
N -2270 -9320 -2240 -9320 {
lab=agnd}
N -2270 -9300 -2240 -9300 {
lab=CLKR[4]}
N -2610 -9460 -2570 -9460 {
lab=vgateN}
N -2610 -9440 -2570 -9440 {
lab=VIN}
N -2270 -9460 -2240 -9460 {
lab=VCM}
N -2270 -9440 -2240 -9440 {
lab=VCM_1}
N -2270 -9420 -2240 -9420 {
lab=agnd}
N -2270 -9400 -2240 -9400 {
lab=CLKR[4]}
N -2610 -9560 -2570 -9560 {
lab=vgateN}
N -2610 -9540 -2570 -9540 {
lab=VIN}
N -2270 -9560 -2240 -9560 {
lab=VCM}
N -2270 -9540 -2240 -9540 {
lab=VCM_1}
N -2270 -9520 -2240 -9520 {
lab=agnd}
N -2270 -9500 -2240 -9500 {
lab=CLKR[4]}
N -2610 -9660 -2570 -9660 {
lab=vgateN}
N -2610 -9640 -2570 -9640 {
lab=VIN}
N -2270 -9660 -2240 -9660 {
lab=VCM}
N -2270 -9640 -2240 -9640 {
lab=VCM_1}
N -2270 -9620 -2240 -9620 {
lab=agnd}
N -2270 -9600 -2240 -9600 {
lab=CLKR[4]}
N -2610 -9770 -2570 -9770 {
lab=vgateN}
N -2610 -9750 -2570 -9750 {
lab=VIN}
N -2270 -9770 -2240 -9770 {
lab=VCM}
N -2270 -9750 -2240 -9750 {
lab=VCM_1}
N -2270 -9730 -2240 -9730 {
lab=agnd}
N -2270 -9710 -2240 -9710 {
lab=CLKR[4]}
N -2610 -9870 -2570 -9870 {
lab=vgateN}
N -2610 -9850 -2570 -9850 {
lab=VIN}
N -2270 -9870 -2240 -9870 {
lab=VCM}
N -2270 -9850 -2240 -9850 {
lab=VCM_1}
N -2270 -9830 -2240 -9830 {
lab=agnd}
N -2270 -9810 -2240 -9810 {
lab=CLKR[4]}
N -2610 -9970 -2570 -9970 {
lab=vgateN}
N -2610 -9950 -2570 -9950 {
lab=VIN}
N -2270 -9970 -2240 -9970 {
lab=VCM}
N -2270 -9950 -2240 -9950 {
lab=VCM_1}
N -2270 -9930 -2240 -9930 {
lab=agnd}
N -2270 -9910 -2240 -9910 {
lab=CLKR[4]}
N -2610 -10070 -2570 -10070 {
lab=vgateN}
N -2610 -10050 -2570 -10050 {
lab=VIN}
N -2270 -10070 -2240 -10070 {
lab=VCM}
N -2270 -10050 -2240 -10050 {
lab=VCM_1}
N -2270 -10030 -2240 -10030 {
lab=agnd}
N -2270 -10010 -2240 -10010 {
lab=CLKR[4]}
N -2610 -10170 -2570 -10170 {
lab=vgateN}
N -2610 -10150 -2570 -10150 {
lab=VIN}
N -2270 -10170 -2240 -10170 {
lab=VCM}
N -2270 -10150 -2240 -10150 {
lab=VCM_1}
N -2270 -10130 -2240 -10130 {
lab=agnd}
N -2270 -10110 -2240 -10110 {
lab=CLKR[4]}
N -2610 -10270 -2570 -10270 {
lab=vgateN}
N -2610 -10250 -2570 -10250 {
lab=VIN}
N -2270 -10270 -2240 -10270 {
lab=VCM}
N -2270 -10250 -2240 -10250 {
lab=VCM_1}
N -2270 -10230 -2240 -10230 {
lab=agnd}
N -2270 -10210 -2240 -10210 {
lab=CLKR[4]}
N -2610 -10370 -2570 -10370 {
lab=vgateN}
N -2610 -10350 -2570 -10350 {
lab=VIN}
N -2270 -10370 -2240 -10370 {
lab=VCM}
N -2270 -10350 -2240 -10350 {
lab=VCM_1}
N -2270 -10330 -2240 -10330 {
lab=agnd}
N -2270 -10310 -2240 -10310 {
lab=CLKR[4]}
N -2610 -10470 -2570 -10470 {
lab=vgateN}
N -2610 -10450 -2570 -10450 {
lab=VIN}
N -2270 -10470 -2240 -10470 {
lab=VCM}
N -2270 -10450 -2240 -10450 {
lab=VCM_1}
N -2270 -10430 -2240 -10430 {
lab=agnd}
N -2270 -10410 -2240 -10410 {
lab=CLKR[4]}
N -2610 -10570 -2570 -10570 {
lab=vgateN}
N -2610 -10550 -2570 -10550 {
lab=VIN}
N -2270 -10570 -2240 -10570 {
lab=VCM}
N -2270 -10550 -2240 -10550 {
lab=VCM_1}
N -2270 -10530 -2240 -10530 {
lab=agnd}
N -2270 -10510 -2240 -10510 {
lab=CLKR[4]}
N -2610 -10670 -2570 -10670 {
lab=vgateN}
N -2610 -10650 -2570 -10650 {
lab=VIN}
N -2270 -10670 -2240 -10670 {
lab=VCM}
N -2270 -10650 -2240 -10650 {
lab=VCM_1}
N -2270 -10630 -2240 -10630 {
lab=agnd}
N -2270 -10610 -2240 -10610 {
lab=CLKR[4]}
N -2610 -10770 -2570 -10770 {
lab=vgateN}
N -2610 -10750 -2570 -10750 {
lab=VIN}
N -2270 -10770 -2240 -10770 {
lab=VCM}
N -2270 -10750 -2240 -10750 {
lab=VCM_1}
N -2270 -10730 -2240 -10730 {
lab=agnd}
N -2270 -10710 -2240 -10710 {
lab=CLKR[4]}
N -2610 -10870 -2570 -10870 {
lab=vgateN}
N -2610 -10850 -2570 -10850 {
lab=VIN}
N -2270 -10870 -2240 -10870 {
lab=VCM}
N -2270 -10850 -2240 -10850 {
lab=VCM_1}
N -2270 -10830 -2240 -10830 {
lab=agnd}
N -2270 -10810 -2240 -10810 {
lab=CLKR[4]}
N -2610 -10970 -2570 -10970 {
lab=vgateN}
N -2610 -10950 -2570 -10950 {
lab=VIN}
N -2270 -10970 -2240 -10970 {
lab=VCM}
N -2270 -10950 -2240 -10950 {
lab=VCM_1}
N -2270 -10930 -2240 -10930 {
lab=agnd}
N -2270 -10910 -2240 -10910 {
lab=CLKR[4]}
N -2610 -11070 -2570 -11070 {
lab=vgateN}
N -2610 -11050 -2570 -11050 {
lab=VIN}
N -2270 -11070 -2240 -11070 {
lab=VCM}
N -2270 -11050 -2240 -11050 {
lab=VCM_1}
N -2270 -11030 -2240 -11030 {
lab=agnd}
N -2270 -11010 -2240 -11010 {
lab=CLKR[4]}
N -2610 -11170 -2570 -11170 {
lab=vgateN}
N -2610 -11150 -2570 -11150 {
lab=VIN}
N -2270 -11170 -2240 -11170 {
lab=VCM}
N -2270 -11150 -2240 -11150 {
lab=VCM_1}
N -2270 -11130 -2240 -11130 {
lab=agnd}
N -2270 -11110 -2240 -11110 {
lab=CLKR[4]}
N -2610 -11270 -2570 -11270 {
lab=vgateN}
N -2610 -11250 -2570 -11250 {
lab=VIN}
N -2270 -11270 -2240 -11270 {
lab=VCM}
N -2270 -11250 -2240 -11250 {
lab=VCM_1}
N -2270 -11230 -2240 -11230 {
lab=agnd}
N -2270 -11210 -2240 -11210 {
lab=CLKR[4]}
N -2610 -11380 -2570 -11380 {
lab=vgateN}
N -2610 -11360 -2570 -11360 {
lab=VIN}
N -2270 -11380 -2240 -11380 {
lab=VCM}
N -2270 -11360 -2240 -11360 {
lab=VCM_1}
N -2270 -11340 -2240 -11340 {
lab=agnd}
N -2270 -11320 -2240 -11320 {
lab=CLKR[4]}
N -2610 -11480 -2570 -11480 {
lab=vgateN}
N -2610 -11460 -2570 -11460 {
lab=VIN}
N -2270 -11480 -2240 -11480 {
lab=VCM}
N -2270 -11460 -2240 -11460 {
lab=VCM_1}
N -2270 -11440 -2240 -11440 {
lab=agnd}
N -2270 -11420 -2240 -11420 {
lab=CLKR[4]}
N -2610 -11580 -2570 -11580 {
lab=vgateN}
N -2610 -11560 -2570 -11560 {
lab=VIN}
N -2270 -11580 -2240 -11580 {
lab=VCM}
N -2270 -11560 -2240 -11560 {
lab=VCM_1}
N -2270 -11540 -2240 -11540 {
lab=agnd}
N -2270 -11520 -2240 -11520 {
lab=CLKR[4]}
N -2610 -11680 -2570 -11680 {
lab=vgateN}
N -2610 -11660 -2570 -11660 {
lab=VIN}
N -2270 -11680 -2240 -11680 {
lab=VCM}
N -2270 -11660 -2240 -11660 {
lab=VCM_1}
N -2270 -11640 -2240 -11640 {
lab=agnd}
N -2270 -11620 -2240 -11620 {
lab=CLKR[4]}
N -2610 -11780 -2570 -11780 {
lab=vgateN}
N -2610 -11760 -2570 -11760 {
lab=VIN}
N -2270 -11780 -2240 -11780 {
lab=VCM}
N -2270 -11760 -2240 -11760 {
lab=VCM_1}
N -2270 -11740 -2240 -11740 {
lab=agnd}
N -2270 -11720 -2240 -11720 {
lab=CLKR[4]}
N -2610 -11880 -2570 -11880 {
lab=vgateN}
N -2610 -11860 -2570 -11860 {
lab=VIN}
N -2270 -11880 -2240 -11880 {
lab=VCM}
N -2270 -11860 -2240 -11860 {
lab=VCM_1}
N -2270 -11840 -2240 -11840 {
lab=agnd}
N -2270 -11820 -2240 -11820 {
lab=CLKR[4]}
N -2610 -11980 -2570 -11980 {
lab=vgateN}
N -2610 -11960 -2570 -11960 {
lab=VIN}
N -2270 -11980 -2240 -11980 {
lab=VCM}
N -2270 -11960 -2240 -11960 {
lab=VCM_1}
N -2270 -11940 -2240 -11940 {
lab=agnd}
N -2270 -11920 -2240 -11920 {
lab=CLKR[4]}
N -2610 -12080 -2570 -12080 {
lab=vgateN}
N -2610 -12060 -2570 -12060 {
lab=VIN}
N -2270 -12080 -2240 -12080 {
lab=VCM}
N -2270 -12060 -2240 -12060 {
lab=VCM_1}
N -2270 -12040 -2240 -12040 {
lab=agnd}
N -2270 -12020 -2240 -12020 {
lab=CLKR[4]}
N -2610 -12180 -2570 -12180 {
lab=vgateN}
N -2610 -12160 -2570 -12160 {
lab=VIN}
N -2270 -12180 -2240 -12180 {
lab=VCM}
N -2270 -12160 -2240 -12160 {
lab=VCM_1}
N -2270 -12140 -2240 -12140 {
lab=agnd}
N -2270 -12120 -2240 -12120 {
lab=CLKR[4]}
N -2610 -12280 -2570 -12280 {
lab=vgateN}
N -2610 -12260 -2570 -12260 {
lab=VIN}
N -2270 -12280 -2240 -12280 {
lab=VCM}
N -2270 -12260 -2240 -12260 {
lab=VCM_1}
N -2270 -12240 -2240 -12240 {
lab=agnd}
N -2270 -12220 -2240 -12220 {
lab=CLKR[4]}
N -2610 -12380 -2570 -12380 {
lab=vgateN}
N -2610 -12360 -2570 -12360 {
lab=VIN}
N -2270 -12380 -2240 -12380 {
lab=VCM}
N -2270 -12360 -2240 -12360 {
lab=VCM_1}
N -2270 -12340 -2240 -12340 {
lab=agnd}
N -2270 -12320 -2240 -12320 {
lab=CLKR[4]}
N -2610 -12480 -2570 -12480 {
lab=vgateN}
N -2610 -12460 -2570 -12460 {
lab=VIN}
N -2270 -12480 -2240 -12480 {
lab=VCM}
N -2270 -12460 -2240 -12460 {
lab=VCM_1}
N -2270 -12440 -2240 -12440 {
lab=agnd}
N -2270 -12420 -2240 -12420 {
lab=CLKR[4]}
N -2610 -12580 -2570 -12580 {
lab=vgateN}
N -2610 -12560 -2570 -12560 {
lab=VIN}
N -2270 -12580 -2240 -12580 {
lab=VCM}
N -2270 -12560 -2240 -12560 {
lab=VCM_1}
N -2270 -12540 -2240 -12540 {
lab=agnd}
N -2270 -12520 -2240 -12520 {
lab=CLKR[4]}
N -2610 -12680 -2570 -12680 {
lab=vgateN}
N -2610 -12660 -2570 -12660 {
lab=VIN}
N -2270 -12680 -2240 -12680 {
lab=VCM}
N -2270 -12660 -2240 -12660 {
lab=VCM_1}
N -2270 -12640 -2240 -12640 {
lab=agnd}
N -2270 -12620 -2240 -12620 {
lab=CLKR[4]}
N -2610 -12780 -2570 -12780 {
lab=vgateN}
N -2610 -12760 -2570 -12760 {
lab=VIN}
N -2270 -12780 -2240 -12780 {
lab=VCM}
N -2270 -12760 -2240 -12760 {
lab=VCM_1}
N -2270 -12740 -2240 -12740 {
lab=agnd}
N -2270 -12720 -2240 -12720 {
lab=CLKR[4]}
N -2610 -12880 -2570 -12880 {
lab=vgateN}
N -2610 -12860 -2570 -12860 {
lab=VIN}
N -2270 -12880 -2240 -12880 {
lab=VCM}
N -2270 -12860 -2240 -12860 {
lab=VCM_1}
N -2270 -12840 -2240 -12840 {
lab=agnd}
N -2270 -12820 -2240 -12820 {
lab=CLKR[4]}
N -2610 -12990 -2570 -12990 {
lab=vgateN}
N -2610 -12970 -2570 -12970 {
lab=VIN}
N -2270 -12990 -2240 -12990 {
lab=VCM}
N -2270 -12970 -2240 -12970 {
lab=VCM_1}
N -2270 -12950 -2240 -12950 {
lab=agnd}
N -2270 -12930 -2240 -12930 {
lab=CLKR[4]}
N -2610 -13090 -2570 -13090 {
lab=vgateN}
N -2610 -13070 -2570 -13070 {
lab=VIN}
N -2270 -13090 -2240 -13090 {
lab=VCM}
N -2270 -13070 -2240 -13070 {
lab=VCM_1}
N -2270 -13050 -2240 -13050 {
lab=agnd}
N -2270 -13030 -2240 -13030 {
lab=CLKR[4]}
N -2610 -13190 -2570 -13190 {
lab=vgateN}
N -2610 -13170 -2570 -13170 {
lab=VIN}
N -2270 -13190 -2240 -13190 {
lab=VCM}
N -2270 -13170 -2240 -13170 {
lab=VCM_1}
N -2270 -13150 -2240 -13150 {
lab=agnd}
N -2270 -13130 -2240 -13130 {
lab=CLKR[4]}
N -2610 -13290 -2570 -13290 {
lab=vgateN}
N -2610 -13270 -2570 -13270 {
lab=VIN}
N -2270 -13290 -2240 -13290 {
lab=VCM}
N -2270 -13270 -2240 -13270 {
lab=VCM_1}
N -2270 -13250 -2240 -13250 {
lab=agnd}
N -2270 -13230 -2240 -13230 {
lab=CLKR[4]}
N -2610 -13390 -2570 -13390 {
lab=vgateN}
N -2610 -13370 -2570 -13370 {
lab=VIN}
N -2270 -13390 -2240 -13390 {
lab=VCM}
N -2270 -13370 -2240 -13370 {
lab=VCM_1}
N -2270 -13350 -2240 -13350 {
lab=agnd}
N -2270 -13330 -2240 -13330 {
lab=CLKR[4]}
N -2610 -13490 -2570 -13490 {
lab=vgateN}
N -2610 -13470 -2570 -13470 {
lab=VIN}
N -2270 -13490 -2240 -13490 {
lab=VCM}
N -2270 -13470 -2240 -13470 {
lab=VCM_1}
N -2270 -13450 -2240 -13450 {
lab=agnd}
N -2270 -13430 -2240 -13430 {
lab=CLKR[4]}
N -2610 -13590 -2570 -13590 {
lab=vgateN}
N -2610 -13570 -2570 -13570 {
lab=VIN}
N -2270 -13590 -2240 -13590 {
lab=VCM}
N -2270 -13570 -2240 -13570 {
lab=VCM_1}
N -2270 -13550 -2240 -13550 {
lab=agnd}
N -2270 -13530 -2240 -13530 {
lab=CLKR[4]}
N -2610 -13690 -2570 -13690 {
lab=vgateN}
N -2610 -13670 -2570 -13670 {
lab=VIN}
N -2270 -13690 -2240 -13690 {
lab=VCM}
N -2270 -13670 -2240 -13670 {
lab=VCM_1}
N -2270 -13650 -2240 -13650 {
lab=agnd}
N -2270 -13630 -2240 -13630 {
lab=CLKR[4]}
N -2610 -13790 -2570 -13790 {
lab=vgateN}
N -2610 -13770 -2570 -13770 {
lab=VIN}
N -2270 -13790 -2240 -13790 {
lab=VCM}
N -2270 -13770 -2240 -13770 {
lab=VCM_1}
N -2270 -13750 -2240 -13750 {
lab=agnd}
N -2270 -13730 -2240 -13730 {
lab=CLKR[4]}
N -2610 -13890 -2570 -13890 {
lab=vgateN}
N -2610 -13870 -2570 -13870 {
lab=VIN}
N -2270 -13890 -2240 -13890 {
lab=VCM}
N -2270 -13870 -2240 -13870 {
lab=VCM_1}
N -2270 -13850 -2240 -13850 {
lab=agnd}
N -2270 -13830 -2240 -13830 {
lab=CLKR[4]}
N -2610 -13990 -2570 -13990 {
lab=vgateN}
N -2610 -13970 -2570 -13970 {
lab=VIN}
N -2270 -13990 -2240 -13990 {
lab=VCM}
N -2270 -13970 -2240 -13970 {
lab=VCM_1}
N -2270 -13950 -2240 -13950 {
lab=agnd}
N -2270 -13930 -2240 -13930 {
lab=CLKR[4]}
N -2610 -14090 -2570 -14090 {
lab=vgateN}
N -2610 -14070 -2570 -14070 {
lab=VIN}
N -2270 -14090 -2240 -14090 {
lab=VCM}
N -2270 -14070 -2240 -14070 {
lab=VCM_1}
N -2270 -14050 -2240 -14050 {
lab=agnd}
N -2270 -14030 -2240 -14030 {
lab=CLKR[4]}
N -2610 -14190 -2570 -14190 {
lab=vgateN}
N -2610 -14170 -2570 -14170 {
lab=VIN}
N -2270 -14190 -2240 -14190 {
lab=VCM}
N -2270 -14170 -2240 -14170 {
lab=VCM_1}
N -2270 -14150 -2240 -14150 {
lab=agnd}
N -2270 -14130 -2240 -14130 {
lab=CLKR[4]}
N -2610 -14290 -2570 -14290 {
lab=vgateN}
N -2610 -14270 -2570 -14270 {
lab=VIN}
N -2270 -14290 -2240 -14290 {
lab=VCM}
N -2270 -14270 -2240 -14270 {
lab=VCM_1}
N -2270 -14250 -2240 -14250 {
lab=agnd}
N -2270 -14230 -2240 -14230 {
lab=CLKR[4]}
N -2610 -14390 -2570 -14390 {
lab=vgateN}
N -2610 -14370 -2570 -14370 {
lab=VIN}
N -2270 -14390 -2240 -14390 {
lab=VCM}
N -2270 -14370 -2240 -14370 {
lab=VCM_1}
N -2270 -14350 -2240 -14350 {
lab=agnd}
N -2270 -14330 -2240 -14330 {
lab=CLKR[4]}
N -2610 -14490 -2570 -14490 {
lab=vgateN}
N -2610 -14470 -2570 -14470 {
lab=VIN}
N -2270 -14490 -2240 -14490 {
lab=VCM}
N -2270 -14470 -2240 -14470 {
lab=VCM_1}
N -2270 -14450 -2240 -14450 {
lab=agnd}
N -2270 -14430 -2240 -14430 {
lab=CLKR[4]}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} 1130 -1670 0 0 {name=x1}
C {lab_pin.sym} 1300 -1700 0 0 {name=p1 sig_type=std_logic lab=VCM}
C {lab_pin.sym} 1300 -1680 0 0 {name=p2 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} 1300 -1660 0 0 {name=p3 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1300 -1640 0 0 {name=p4 sig_type=std_logic lab=CLK1D}
C {lab_pin.sym} 960 -1700 0 0 {name=p5 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} 960 -1680 0 0 {name=p6 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} 680 -1670 0 0 {name=x2}
C {lab_pin.sym} 850 -1700 0 0 {name=p7 sig_type=std_logic lab=VCM}
C {lab_pin.sym} 850 -1680 0 0 {name=p8 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} 850 -1660 0 0 {name=p9 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 850 -1640 0 0 {name=p10 sig_type=std_logic lab=CLKR[7]}
C {lab_pin.sym} 510 -1700 0 0 {name=p11 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} 510 -1680 0 0 {name=p12 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} 230 -1660 0 0 {name=x3}
C {lab_pin.sym} 400 -1690 0 0 {name=p13 sig_type=std_logic lab=VCM}
C {lab_pin.sym} 400 -1670 0 0 {name=p14 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} 400 -1650 0 0 {name=p15 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 400 -1630 0 0 {name=p16 sig_type=std_logic lab=CLKR[6]}
C {lab_pin.sym} 60 -1690 0 0 {name=p17 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} 60 -1670 0 0 {name=p18 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} 230 -1760 0 0 {name=x4}
C {lab_pin.sym} 400 -1790 0 0 {name=p19 sig_type=std_logic lab=VCM}
C {lab_pin.sym} 400 -1770 0 0 {name=p20 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} 400 -1750 0 0 {name=p21 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 400 -1730 0 0 {name=p22 sig_type=std_logic lab=CLKR[6]}
C {lab_pin.sym} 60 -1790 0 0 {name=p23 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} 60 -1770 0 0 {name=p24 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -210 -1660 0 0 {name=x5}
C {lab_pin.sym} -40 -1690 0 0 {name=p25 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -40 -1670 0 0 {name=p26 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -40 -1650 0 0 {name=p27 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -40 -1630 0 0 {name=p28 sig_type=std_logic lab=CLKR[5]}
C {lab_pin.sym} -380 -1690 0 0 {name=p29 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -380 -1670 0 0 {name=p30 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -210 -1770 0 0 {name=x6}
C {lab_pin.sym} -40 -1800 0 0 {name=p31 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -40 -1780 0 0 {name=p32 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -40 -1760 0 0 {name=p33 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -40 -1740 0 0 {name=p34 sig_type=std_logic lab=CLKR[5]}
C {lab_pin.sym} -380 -1800 0 0 {name=p35 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -380 -1780 0 0 {name=p36 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -210 -1860 0 0 {name=x7}
C {lab_pin.sym} -40 -1890 0 0 {name=p37 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -40 -1870 0 0 {name=p38 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -40 -1850 0 0 {name=p39 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -40 -1830 0 0 {name=p40 sig_type=std_logic lab=CLKR[5]}
C {lab_pin.sym} -380 -1890 0 0 {name=p41 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -380 -1870 0 0 {name=p42 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -210 -1970 0 0 {name=x8}
C {lab_pin.sym} -40 -2000 0 0 {name=p43 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -40 -1980 0 0 {name=p44 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -40 -1960 0 0 {name=p45 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -40 -1940 0 0 {name=p46 sig_type=std_logic lab=CLKR[5]}
C {lab_pin.sym} -380 -2000 0 0 {name=p47 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -380 -1980 0 0 {name=p48 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -650 -1660 0 0 {name=x9}
C {lab_pin.sym} -480 -1690 0 0 {name=p49 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -480 -1670 0 0 {name=p50 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -480 -1650 0 0 {name=p51 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -480 -1630 0 0 {name=p52 sig_type=std_logic lab=CLKR[4]}
C {lab_pin.sym} -820 -1690 0 0 {name=p53 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -820 -1670 0 0 {name=p54 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -650 -1750 0 0 {name=x10}
C {lab_pin.sym} -480 -1780 0 0 {name=p55 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -480 -1760 0 0 {name=p56 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -480 -1740 0 0 {name=p57 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -480 -1720 0 0 {name=p58 sig_type=std_logic lab=CLKR[4]}
C {lab_pin.sym} -820 -1780 0 0 {name=p59 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -820 -1760 0 0 {name=p60 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -650 -1840 0 0 {name=x11}
C {lab_pin.sym} -480 -1870 0 0 {name=p61 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -480 -1850 0 0 {name=p62 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -480 -1830 0 0 {name=p63 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -480 -1810 0 0 {name=p64 sig_type=std_logic lab=CLKR[4]}
C {lab_pin.sym} -820 -1870 0 0 {name=p65 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -820 -1850 0 0 {name=p66 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -650 -1930 0 0 {name=x12}
C {lab_pin.sym} -480 -1960 0 0 {name=p67 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -480 -1940 0 0 {name=p68 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -480 -1920 0 0 {name=p69 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -480 -1900 0 0 {name=p70 sig_type=std_logic lab=CLKR[4]}
C {lab_pin.sym} -820 -1960 0 0 {name=p71 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -820 -1940 0 0 {name=p72 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -650 -2030 0 0 {name=x13}
C {lab_pin.sym} -480 -2060 0 0 {name=p73 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -480 -2040 0 0 {name=p74 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -480 -2020 0 0 {name=p75 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -480 -2000 0 0 {name=p76 sig_type=std_logic lab=CLKR[4]}
C {lab_pin.sym} -820 -2060 0 0 {name=p77 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -820 -2040 0 0 {name=p78 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -650 -2120 0 0 {name=x14}
C {lab_pin.sym} -480 -2150 0 0 {name=p79 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -480 -2130 0 0 {name=p80 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -480 -2110 0 0 {name=p81 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -480 -2090 0 0 {name=p82 sig_type=std_logic lab=CLKR[4]}
C {lab_pin.sym} -820 -2150 0 0 {name=p83 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -820 -2130 0 0 {name=p84 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -650 -2210 0 0 {name=x15}
C {lab_pin.sym} -480 -2240 0 0 {name=p85 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -480 -2220 0 0 {name=p86 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -480 -2200 0 0 {name=p87 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -480 -2180 0 0 {name=p88 sig_type=std_logic lab=CLKR[4]}
C {lab_pin.sym} -820 -2240 0 0 {name=p89 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -820 -2220 0 0 {name=p90 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -650 -2300 0 0 {name=x16}
C {lab_pin.sym} -480 -2330 0 0 {name=p91 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -480 -2310 0 0 {name=p92 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -480 -2290 0 0 {name=p93 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -480 -2270 0 0 {name=p94 sig_type=std_logic lab=CLKR[4]}
C {lab_pin.sym} -820 -2330 0 0 {name=p95 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -820 -2310 0 0 {name=p96 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -1660 0 0 {name=x17}
C {lab_pin.sym} -940 -1690 0 0 {name=p97 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -1670 0 0 {name=p98 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -1650 0 0 {name=p99 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -1630 0 0 {name=p100 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -1690 0 0 {name=p101 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -1670 0 0 {name=p102 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -1760 0 0 {name=x18}
C {lab_pin.sym} -940 -1790 0 0 {name=p103 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -1770 0 0 {name=p104 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -1750 0 0 {name=p105 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -1730 0 0 {name=p106 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -1790 0 0 {name=p107 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -1770 0 0 {name=p108 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -1860 0 0 {name=x19}
C {lab_pin.sym} -940 -1890 0 0 {name=p109 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -1870 0 0 {name=p110 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -1850 0 0 {name=p111 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -1830 0 0 {name=p112 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -1890 0 0 {name=p113 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -1870 0 0 {name=p114 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -1960 0 0 {name=x20}
C {lab_pin.sym} -940 -1990 0 0 {name=p115 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -1970 0 0 {name=p116 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -1950 0 0 {name=p117 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -1930 0 0 {name=p118 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -1990 0 0 {name=p119 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -1970 0 0 {name=p120 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2050 0 0 {name=x21}
C {lab_pin.sym} -940 -2080 0 0 {name=p121 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2060 0 0 {name=p122 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2040 0 0 {name=p123 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2020 0 0 {name=p124 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2080 0 0 {name=p125 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2060 0 0 {name=p126 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2150 0 0 {name=x22}
C {lab_pin.sym} -940 -2180 0 0 {name=p127 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2160 0 0 {name=p128 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2140 0 0 {name=p129 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2120 0 0 {name=p130 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2180 0 0 {name=p131 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2160 0 0 {name=p132 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2250 0 0 {name=x23}
C {lab_pin.sym} -940 -2280 0 0 {name=p133 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2260 0 0 {name=p134 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2240 0 0 {name=p135 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2220 0 0 {name=p136 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2280 0 0 {name=p137 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2260 0 0 {name=p138 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2350 0 0 {name=x24}
C {lab_pin.sym} -940 -2380 0 0 {name=p139 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2360 0 0 {name=p140 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2340 0 0 {name=p141 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2320 0 0 {name=p142 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2380 0 0 {name=p143 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2360 0 0 {name=p144 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2450 0 0 {name=x25}
C {lab_pin.sym} -940 -2480 0 0 {name=p145 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2460 0 0 {name=p146 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2440 0 0 {name=p147 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2420 0 0 {name=p148 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2480 0 0 {name=p149 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2460 0 0 {name=p150 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2550 0 0 {name=x26}
C {lab_pin.sym} -940 -2580 0 0 {name=p151 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2560 0 0 {name=p152 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2540 0 0 {name=p153 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2520 0 0 {name=p154 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2580 0 0 {name=p155 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2560 0 0 {name=p156 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2650 0 0 {name=x27}
C {lab_pin.sym} -940 -2680 0 0 {name=p157 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2660 0 0 {name=p158 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2640 0 0 {name=p159 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2620 0 0 {name=p160 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2680 0 0 {name=p161 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2660 0 0 {name=p162 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2750 0 0 {name=x28}
C {lab_pin.sym} -940 -2780 0 0 {name=p163 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2760 0 0 {name=p164 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2740 0 0 {name=p165 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2720 0 0 {name=p166 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2780 0 0 {name=p167 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2760 0 0 {name=p168 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2840 0 0 {name=x29}
C {lab_pin.sym} -940 -2870 0 0 {name=p169 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2850 0 0 {name=p170 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2830 0 0 {name=p171 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2810 0 0 {name=p172 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2870 0 0 {name=p173 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2850 0 0 {name=p174 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -2940 0 0 {name=x30}
C {lab_pin.sym} -940 -2970 0 0 {name=p175 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -2950 0 0 {name=p176 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -2930 0 0 {name=p177 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -2910 0 0 {name=p178 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -2970 0 0 {name=p179 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -2950 0 0 {name=p180 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -3040 0 0 {name=x31}
C {lab_pin.sym} -940 -3070 0 0 {name=p181 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -3050 0 0 {name=p182 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -3030 0 0 {name=p183 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -3010 0 0 {name=p184 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -3070 0 0 {name=p185 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -3050 0 0 {name=p186 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1110 -3140 0 0 {name=x32}
C {lab_pin.sym} -940 -3170 0 0 {name=p187 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -940 -3150 0 0 {name=p188 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -940 -3130 0 0 {name=p189 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -940 -3110 0 0 {name=p190 sig_type=std_logic lab=CLKR[3]}
C {lab_pin.sym} -1280 -3170 0 0 {name=p191 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1280 -3150 0 0 {name=p192 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -1660 0 0 {name=x33}
C {lab_pin.sym} -1380 -1690 0 0 {name=p193 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -1670 0 0 {name=p194 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -1650 0 0 {name=p195 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -1630 0 0 {name=p196 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -1690 0 0 {name=p197 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -1670 0 0 {name=p198 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -1760 0 0 {name=x34}
C {lab_pin.sym} -1380 -1790 0 0 {name=p199 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -1770 0 0 {name=p200 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -1750 0 0 {name=p201 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -1730 0 0 {name=p202 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -1790 0 0 {name=p203 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -1770 0 0 {name=p204 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -1860 0 0 {name=x35}
C {lab_pin.sym} -1380 -1890 0 0 {name=p205 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -1870 0 0 {name=p206 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -1850 0 0 {name=p207 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -1830 0 0 {name=p208 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -1890 0 0 {name=p209 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -1870 0 0 {name=p210 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -1960 0 0 {name=x36}
C {lab_pin.sym} -1380 -1990 0 0 {name=p211 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -1970 0 0 {name=p212 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -1950 0 0 {name=p213 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -1930 0 0 {name=p214 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -1990 0 0 {name=p215 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -1970 0 0 {name=p216 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2050 0 0 {name=x37}
C {lab_pin.sym} -1380 -2080 0 0 {name=p217 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2060 0 0 {name=p218 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2040 0 0 {name=p219 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2020 0 0 {name=p220 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2080 0 0 {name=p221 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2060 0 0 {name=p222 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2150 0 0 {name=x38}
C {lab_pin.sym} -1380 -2180 0 0 {name=p223 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2160 0 0 {name=p224 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2140 0 0 {name=p225 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2120 0 0 {name=p226 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2180 0 0 {name=p227 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2160 0 0 {name=p228 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2250 0 0 {name=x39}
C {lab_pin.sym} -1380 -2280 0 0 {name=p229 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2260 0 0 {name=p230 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2240 0 0 {name=p231 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2220 0 0 {name=p232 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2280 0 0 {name=p233 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2260 0 0 {name=p234 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2350 0 0 {name=x40}
C {lab_pin.sym} -1380 -2380 0 0 {name=p235 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2360 0 0 {name=p236 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2340 0 0 {name=p237 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2320 0 0 {name=p238 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2380 0 0 {name=p239 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2360 0 0 {name=p240 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2450 0 0 {name=x41}
C {lab_pin.sym} -1380 -2480 0 0 {name=p241 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2460 0 0 {name=p242 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2440 0 0 {name=p243 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2420 0 0 {name=p244 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2480 0 0 {name=p245 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2460 0 0 {name=p246 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2550 0 0 {name=x42}
C {lab_pin.sym} -1380 -2580 0 0 {name=p247 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2560 0 0 {name=p248 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2540 0 0 {name=p249 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2520 0 0 {name=p250 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2580 0 0 {name=p251 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2560 0 0 {name=p252 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2650 0 0 {name=x43}
C {lab_pin.sym} -1380 -2680 0 0 {name=p253 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2660 0 0 {name=p254 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2640 0 0 {name=p255 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2620 0 0 {name=p256 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2680 0 0 {name=p257 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2660 0 0 {name=p258 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2750 0 0 {name=x44}
C {lab_pin.sym} -1380 -2780 0 0 {name=p259 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2760 0 0 {name=p260 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2740 0 0 {name=p261 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2720 0 0 {name=p262 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2780 0 0 {name=p263 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2760 0 0 {name=p264 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2840 0 0 {name=x45}
C {lab_pin.sym} -1380 -2870 0 0 {name=p265 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2850 0 0 {name=p266 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2830 0 0 {name=p267 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2810 0 0 {name=p268 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2870 0 0 {name=p269 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2850 0 0 {name=p270 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -2940 0 0 {name=x46}
C {lab_pin.sym} -1380 -2970 0 0 {name=p271 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -2950 0 0 {name=p272 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -2930 0 0 {name=p273 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -2910 0 0 {name=p274 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -2970 0 0 {name=p275 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -2950 0 0 {name=p276 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3040 0 0 {name=x47}
C {lab_pin.sym} -1380 -3070 0 0 {name=p277 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3050 0 0 {name=p278 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3030 0 0 {name=p279 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3010 0 0 {name=p280 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3070 0 0 {name=p281 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3050 0 0 {name=p282 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3140 0 0 {name=x48}
C {lab_pin.sym} -1380 -3170 0 0 {name=p283 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3150 0 0 {name=p284 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3130 0 0 {name=p285 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3110 0 0 {name=p286 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3170 0 0 {name=p287 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3150 0 0 {name=p288 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3240 0 0 {name=x49}
C {lab_pin.sym} -1380 -3270 0 0 {name=p289 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3250 0 0 {name=p290 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3230 0 0 {name=p291 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3210 0 0 {name=p292 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3270 0 0 {name=p293 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3250 0 0 {name=p294 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3340 0 0 {name=x50}
C {lab_pin.sym} -1380 -3370 0 0 {name=p295 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3350 0 0 {name=p296 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3330 0 0 {name=p297 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3310 0 0 {name=p298 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3370 0 0 {name=p299 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3350 0 0 {name=p300 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3440 0 0 {name=x51}
C {lab_pin.sym} -1380 -3470 0 0 {name=p301 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3450 0 0 {name=p302 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3430 0 0 {name=p303 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3410 0 0 {name=p304 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3470 0 0 {name=p305 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3450 0 0 {name=p306 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3540 0 0 {name=x52}
C {lab_pin.sym} -1380 -3570 0 0 {name=p307 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3550 0 0 {name=p308 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3530 0 0 {name=p309 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3510 0 0 {name=p310 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3570 0 0 {name=p311 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3550 0 0 {name=p312 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3630 0 0 {name=x53}
C {lab_pin.sym} -1380 -3660 0 0 {name=p313 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3640 0 0 {name=p314 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3620 0 0 {name=p315 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3600 0 0 {name=p316 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3660 0 0 {name=p317 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3640 0 0 {name=p318 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3730 0 0 {name=x54}
C {lab_pin.sym} -1380 -3760 0 0 {name=p319 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3740 0 0 {name=p320 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3720 0 0 {name=p321 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3700 0 0 {name=p322 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3760 0 0 {name=p323 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3740 0 0 {name=p324 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3830 0 0 {name=x55}
C {lab_pin.sym} -1380 -3860 0 0 {name=p325 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3840 0 0 {name=p326 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3820 0 0 {name=p327 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3800 0 0 {name=p328 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3860 0 0 {name=p329 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3840 0 0 {name=p330 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -3930 0 0 {name=x56}
C {lab_pin.sym} -1380 -3960 0 0 {name=p331 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -3940 0 0 {name=p332 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -3920 0 0 {name=p333 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -3900 0 0 {name=p334 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -3960 0 0 {name=p335 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -3940 0 0 {name=p336 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -4030 0 0 {name=x57}
C {lab_pin.sym} -1380 -4060 0 0 {name=p337 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -4040 0 0 {name=p338 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -4020 0 0 {name=p339 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -4000 0 0 {name=p340 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -4060 0 0 {name=p341 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -4040 0 0 {name=p342 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -4130 0 0 {name=x58}
C {lab_pin.sym} -1380 -4160 0 0 {name=p343 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -4140 0 0 {name=p344 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -4120 0 0 {name=p345 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -4100 0 0 {name=p346 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -4160 0 0 {name=p347 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -4140 0 0 {name=p348 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -4230 0 0 {name=x59}
C {lab_pin.sym} -1380 -4260 0 0 {name=p349 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -4240 0 0 {name=p350 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -4220 0 0 {name=p351 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -4200 0 0 {name=p352 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -4260 0 0 {name=p353 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -4240 0 0 {name=p354 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -4330 0 0 {name=x60}
C {lab_pin.sym} -1380 -4360 0 0 {name=p355 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -4340 0 0 {name=p356 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -4320 0 0 {name=p357 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -4300 0 0 {name=p358 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -4360 0 0 {name=p359 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -4340 0 0 {name=p360 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -4420 0 0 {name=x61}
C {lab_pin.sym} -1380 -4450 0 0 {name=p361 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -4430 0 0 {name=p362 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -4410 0 0 {name=p363 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -4390 0 0 {name=p364 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -4450 0 0 {name=p365 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -4430 0 0 {name=p366 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -4520 0 0 {name=x62}
C {lab_pin.sym} -1380 -4550 0 0 {name=p367 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -4530 0 0 {name=p368 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -4510 0 0 {name=p369 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -4490 0 0 {name=p370 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -4550 0 0 {name=p371 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -4530 0 0 {name=p372 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -4620 0 0 {name=x63}
C {lab_pin.sym} -1380 -4650 0 0 {name=p373 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -4630 0 0 {name=p374 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -4610 0 0 {name=p375 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -4590 0 0 {name=p376 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -4650 0 0 {name=p377 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -4630 0 0 {name=p378 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -1550 -4720 0 0 {name=x64}
C {lab_pin.sym} -1380 -4750 0 0 {name=p379 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1380 -4730 0 0 {name=p380 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1380 -4710 0 0 {name=p381 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1380 -4690 0 0 {name=p382 sig_type=std_logic lab=CLKR[2]}
C {lab_pin.sym} -1720 -4750 0 0 {name=p383 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -1720 -4730 0 0 {name=p384 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -1670 0 0 {name=x65}
C {lab_pin.sym} -1830 -1700 0 0 {name=p385 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -1680 0 0 {name=p386 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -1660 0 0 {name=p387 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -1640 0 0 {name=p388 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -1700 0 0 {name=p389 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -1680 0 0 {name=p390 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -1770 0 0 {name=x66}
C {lab_pin.sym} -1830 -1800 0 0 {name=p391 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -1780 0 0 {name=p392 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -1760 0 0 {name=p393 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -1740 0 0 {name=p394 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -1800 0 0 {name=p395 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -1780 0 0 {name=p396 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -1860 0 0 {name=x67}
C {lab_pin.sym} -1830 -1890 0 0 {name=p397 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -1870 0 0 {name=p398 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -1850 0 0 {name=p399 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -1830 0 0 {name=p400 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -1890 0 0 {name=p401 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -1870 0 0 {name=p402 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -1960 0 0 {name=x68}
C {lab_pin.sym} -1830 -1990 0 0 {name=p403 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -1970 0 0 {name=p404 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -1950 0 0 {name=p405 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -1930 0 0 {name=p406 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -1990 0 0 {name=p407 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -1970 0 0 {name=p408 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2050 0 0 {name=x69}
C {lab_pin.sym} -1830 -2080 0 0 {name=p409 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2060 0 0 {name=p410 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2040 0 0 {name=p411 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2020 0 0 {name=p412 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2080 0 0 {name=p413 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2060 0 0 {name=p414 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2150 0 0 {name=x70}
C {lab_pin.sym} -1830 -2180 0 0 {name=p415 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2160 0 0 {name=p416 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2140 0 0 {name=p417 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2120 0 0 {name=p418 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2180 0 0 {name=p419 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2160 0 0 {name=p420 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2240 0 0 {name=x71}
C {lab_pin.sym} -1830 -2270 0 0 {name=p421 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2250 0 0 {name=p422 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2230 0 0 {name=p423 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2210 0 0 {name=p424 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2270 0 0 {name=p425 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2250 0 0 {name=p426 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2340 0 0 {name=x72}
C {lab_pin.sym} -1830 -2370 0 0 {name=p427 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2350 0 0 {name=p428 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2330 0 0 {name=p429 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2310 0 0 {name=p430 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2370 0 0 {name=p431 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2350 0 0 {name=p432 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2440 0 0 {name=x73}
C {lab_pin.sym} -1830 -2470 0 0 {name=p433 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2450 0 0 {name=p434 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2430 0 0 {name=p435 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2410 0 0 {name=p436 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2470 0 0 {name=p437 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2450 0 0 {name=p438 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2540 0 0 {name=x74}
C {lab_pin.sym} -1830 -2570 0 0 {name=p439 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2550 0 0 {name=p440 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2530 0 0 {name=p441 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2510 0 0 {name=p442 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2570 0 0 {name=p443 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2550 0 0 {name=p444 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2630 0 0 {name=x75}
C {lab_pin.sym} -1830 -2660 0 0 {name=p445 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2640 0 0 {name=p446 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2620 0 0 {name=p447 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2600 0 0 {name=p448 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2660 0 0 {name=p449 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2640 0 0 {name=p450 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2730 0 0 {name=x76}
C {lab_pin.sym} -1830 -2760 0 0 {name=p451 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2740 0 0 {name=p452 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2720 0 0 {name=p453 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2700 0 0 {name=p454 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2760 0 0 {name=p455 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2740 0 0 {name=p456 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2820 0 0 {name=x77}
C {lab_pin.sym} -1830 -2850 0 0 {name=p457 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2830 0 0 {name=p458 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2810 0 0 {name=p459 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2790 0 0 {name=p460 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2850 0 0 {name=p461 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2830 0 0 {name=p462 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -2920 0 0 {name=x78}
C {lab_pin.sym} -1830 -2950 0 0 {name=p463 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -2930 0 0 {name=p464 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -2910 0 0 {name=p465 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2890 0 0 {name=p466 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -2950 0 0 {name=p467 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -2930 0 0 {name=p468 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3010 0 0 {name=x79}
C {lab_pin.sym} -1830 -3040 0 0 {name=p469 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3020 0 0 {name=p470 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3000 0 0 {name=p471 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -2980 0 0 {name=p472 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3040 0 0 {name=p473 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3020 0 0 {name=p474 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3110 0 0 {name=x80}
C {lab_pin.sym} -1830 -3140 0 0 {name=p475 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3120 0 0 {name=p476 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3100 0 0 {name=p477 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3080 0 0 {name=p478 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3140 0 0 {name=p479 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3120 0 0 {name=p480 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3230 0 0 {name=x81}
C {lab_pin.sym} -1830 -3260 0 0 {name=p481 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3240 0 0 {name=p482 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3220 0 0 {name=p483 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3200 0 0 {name=p484 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3260 0 0 {name=p485 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3240 0 0 {name=p486 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3330 0 0 {name=x82}
C {lab_pin.sym} -1830 -3360 0 0 {name=p487 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3340 0 0 {name=p488 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3320 0 0 {name=p489 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3300 0 0 {name=p490 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3360 0 0 {name=p491 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3340 0 0 {name=p492 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3420 0 0 {name=x83}
C {lab_pin.sym} -1830 -3450 0 0 {name=p493 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3430 0 0 {name=p494 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3410 0 0 {name=p495 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3390 0 0 {name=p496 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3450 0 0 {name=p497 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3430 0 0 {name=p498 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3520 0 0 {name=x84}
C {lab_pin.sym} -1830 -3550 0 0 {name=p499 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3530 0 0 {name=p500 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3510 0 0 {name=p501 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3490 0 0 {name=p502 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3550 0 0 {name=p503 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3530 0 0 {name=p504 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3610 0 0 {name=x85}
C {lab_pin.sym} -1830 -3640 0 0 {name=p505 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3620 0 0 {name=p506 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3600 0 0 {name=p507 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3580 0 0 {name=p508 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3640 0 0 {name=p509 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3620 0 0 {name=p510 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3710 0 0 {name=x86}
C {lab_pin.sym} -1830 -3740 0 0 {name=p511 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3720 0 0 {name=p512 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3700 0 0 {name=p513 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3680 0 0 {name=p514 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3740 0 0 {name=p515 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3720 0 0 {name=p516 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3800 0 0 {name=x87}
C {lab_pin.sym} -1830 -3830 0 0 {name=p517 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3810 0 0 {name=p518 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3790 0 0 {name=p519 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3770 0 0 {name=p520 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3830 0 0 {name=p521 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3810 0 0 {name=p522 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -3900 0 0 {name=x88}
C {lab_pin.sym} -1830 -3930 0 0 {name=p523 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -3910 0 0 {name=p524 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3890 0 0 {name=p525 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3870 0 0 {name=p526 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -3930 0 0 {name=p527 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -3910 0 0 {name=p528 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4000 0 0 {name=x89}
C {lab_pin.sym} -1830 -4030 0 0 {name=p529 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4010 0 0 {name=p530 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -3990 0 0 {name=p531 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -3970 0 0 {name=p532 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4030 0 0 {name=p533 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4010 0 0 {name=p534 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4100 0 0 {name=x90}
C {lab_pin.sym} -1830 -4130 0 0 {name=p535 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4110 0 0 {name=p536 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4090 0 0 {name=p537 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4070 0 0 {name=p538 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4130 0 0 {name=p539 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4110 0 0 {name=p540 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4190 0 0 {name=x91}
C {lab_pin.sym} -1830 -4220 0 0 {name=p541 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4200 0 0 {name=p542 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4180 0 0 {name=p543 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4160 0 0 {name=p544 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4220 0 0 {name=p545 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4200 0 0 {name=p546 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4290 0 0 {name=x92}
C {lab_pin.sym} -1830 -4320 0 0 {name=p547 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4300 0 0 {name=p548 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4280 0 0 {name=p549 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4260 0 0 {name=p550 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4320 0 0 {name=p551 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4300 0 0 {name=p552 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4380 0 0 {name=x93}
C {lab_pin.sym} -1830 -4410 0 0 {name=p553 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4390 0 0 {name=p554 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4370 0 0 {name=p555 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4350 0 0 {name=p556 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4410 0 0 {name=p557 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4390 0 0 {name=p558 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4480 0 0 {name=x94}
C {lab_pin.sym} -1830 -4510 0 0 {name=p559 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4490 0 0 {name=p560 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4470 0 0 {name=p561 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4450 0 0 {name=p562 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4510 0 0 {name=p563 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4490 0 0 {name=p564 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4570 0 0 {name=x95}
C {lab_pin.sym} -1830 -4600 0 0 {name=p565 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4580 0 0 {name=p566 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4560 0 0 {name=p567 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4540 0 0 {name=p568 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4600 0 0 {name=p569 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4580 0 0 {name=p570 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4670 0 0 {name=x96}
C {lab_pin.sym} -1830 -4700 0 0 {name=p571 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4680 0 0 {name=p572 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4660 0 0 {name=p573 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4640 0 0 {name=p574 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4700 0 0 {name=p575 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4680 0 0 {name=p576 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4780 0 0 {name=x97}
C {lab_pin.sym} -1830 -4810 0 0 {name=p577 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4790 0 0 {name=p578 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4770 0 0 {name=p579 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4750 0 0 {name=p580 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4810 0 0 {name=p581 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4790 0 0 {name=p582 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4880 0 0 {name=x98}
C {lab_pin.sym} -1830 -4910 0 0 {name=p583 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4890 0 0 {name=p584 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4870 0 0 {name=p585 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4850 0 0 {name=p586 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -4910 0 0 {name=p587 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4890 0 0 {name=p588 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -4970 0 0 {name=x99}
C {lab_pin.sym} -1830 -5000 0 0 {name=p589 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -4980 0 0 {name=p590 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -4960 0 0 {name=p591 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -4940 0 0 {name=p592 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5000 0 0 {name=p593 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -4980 0 0 {name=p594 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5070 0 0 {name=x100}
C {lab_pin.sym} -1830 -5100 0 0 {name=p595 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5080 0 0 {name=p596 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5060 0 0 {name=p597 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5040 0 0 {name=p598 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5100 0 0 {name=p599 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5080 0 0 {name=p600 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5160 0 0 {name=x101}
C {lab_pin.sym} -1830 -5190 0 0 {name=p601 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5170 0 0 {name=p602 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5150 0 0 {name=p603 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5130 0 0 {name=p604 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5190 0 0 {name=p605 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5170 0 0 {name=p606 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5260 0 0 {name=x102}
C {lab_pin.sym} -1830 -5290 0 0 {name=p607 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5270 0 0 {name=p608 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5250 0 0 {name=p609 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5230 0 0 {name=p610 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5290 0 0 {name=p611 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5270 0 0 {name=p612 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5350 0 0 {name=x103}
C {lab_pin.sym} -1830 -5380 0 0 {name=p613 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5360 0 0 {name=p614 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5340 0 0 {name=p615 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5320 0 0 {name=p616 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5380 0 0 {name=p617 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5360 0 0 {name=p618 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5450 0 0 {name=x104}
C {lab_pin.sym} -1830 -5480 0 0 {name=p619 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5460 0 0 {name=p620 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5440 0 0 {name=p621 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5420 0 0 {name=p622 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5480 0 0 {name=p623 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5460 0 0 {name=p624 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5550 0 0 {name=x105}
C {lab_pin.sym} -1830 -5580 0 0 {name=p625 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5560 0 0 {name=p626 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5540 0 0 {name=p627 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5520 0 0 {name=p628 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5580 0 0 {name=p629 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5560 0 0 {name=p630 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5650 0 0 {name=x106}
C {lab_pin.sym} -1830 -5680 0 0 {name=p631 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5660 0 0 {name=p632 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5640 0 0 {name=p633 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5620 0 0 {name=p634 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5680 0 0 {name=p635 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5660 0 0 {name=p636 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5740 0 0 {name=x107}
C {lab_pin.sym} -1830 -5770 0 0 {name=p637 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5750 0 0 {name=p638 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5730 0 0 {name=p639 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5710 0 0 {name=p640 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5770 0 0 {name=p641 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5750 0 0 {name=p642 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5840 0 0 {name=x108}
C {lab_pin.sym} -1830 -5870 0 0 {name=p643 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5850 0 0 {name=p644 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5830 0 0 {name=p645 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5810 0 0 {name=p646 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5870 0 0 {name=p647 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5850 0 0 {name=p648 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -5930 0 0 {name=x109}
C {lab_pin.sym} -1830 -5960 0 0 {name=p649 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -5940 0 0 {name=p650 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -5920 0 0 {name=p651 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -5900 0 0 {name=p652 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -5960 0 0 {name=p653 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -5940 0 0 {name=p654 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6030 0 0 {name=x110}
C {lab_pin.sym} -1830 -6060 0 0 {name=p655 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6040 0 0 {name=p656 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6020 0 0 {name=p657 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6000 0 0 {name=p658 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6060 0 0 {name=p659 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6040 0 0 {name=p660 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6120 0 0 {name=x111}
C {lab_pin.sym} -1830 -6150 0 0 {name=p661 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6130 0 0 {name=p662 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6110 0 0 {name=p663 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6090 0 0 {name=p664 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6150 0 0 {name=p665 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6130 0 0 {name=p666 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6220 0 0 {name=x112}
C {lab_pin.sym} -1830 -6250 0 0 {name=p667 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6230 0 0 {name=p668 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6210 0 0 {name=p669 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6190 0 0 {name=p670 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6250 0 0 {name=p671 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6230 0 0 {name=p672 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6340 0 0 {name=x113}
C {lab_pin.sym} -1830 -6370 0 0 {name=p673 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6350 0 0 {name=p674 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6330 0 0 {name=p675 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6310 0 0 {name=p676 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6370 0 0 {name=p677 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6350 0 0 {name=p678 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6440 0 0 {name=x114}
C {lab_pin.sym} -1830 -6470 0 0 {name=p679 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6450 0 0 {name=p680 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6430 0 0 {name=p681 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6410 0 0 {name=p682 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6470 0 0 {name=p683 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6450 0 0 {name=p684 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6530 0 0 {name=x115}
C {lab_pin.sym} -1830 -6560 0 0 {name=p685 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6540 0 0 {name=p686 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6520 0 0 {name=p687 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6500 0 0 {name=p688 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6560 0 0 {name=p689 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6540 0 0 {name=p690 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6630 0 0 {name=x116}
C {lab_pin.sym} -1830 -6660 0 0 {name=p691 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6640 0 0 {name=p692 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6620 0 0 {name=p693 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6600 0 0 {name=p694 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6660 0 0 {name=p695 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6640 0 0 {name=p696 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6720 0 0 {name=x117}
C {lab_pin.sym} -1830 -6750 0 0 {name=p697 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6730 0 0 {name=p698 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6710 0 0 {name=p699 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6690 0 0 {name=p700 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6750 0 0 {name=p701 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6730 0 0 {name=p702 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6820 0 0 {name=x118}
C {lab_pin.sym} -1830 -6850 0 0 {name=p703 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6830 0 0 {name=p704 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6810 0 0 {name=p705 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6790 0 0 {name=p706 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6850 0 0 {name=p707 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6830 0 0 {name=p708 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -6910 0 0 {name=x119}
C {lab_pin.sym} -1830 -6940 0 0 {name=p709 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -6920 0 0 {name=p710 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -6900 0 0 {name=p711 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6880 0 0 {name=p712 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -6940 0 0 {name=p713 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -6920 0 0 {name=p714 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7010 0 0 {name=x120}
C {lab_pin.sym} -1830 -7040 0 0 {name=p715 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7020 0 0 {name=p716 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7000 0 0 {name=p717 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -6980 0 0 {name=p718 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7040 0 0 {name=p719 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7020 0 0 {name=p720 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7110 0 0 {name=x121}
C {lab_pin.sym} -1830 -7140 0 0 {name=p721 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7120 0 0 {name=p722 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7100 0 0 {name=p723 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -7080 0 0 {name=p724 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7140 0 0 {name=p725 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7120 0 0 {name=p726 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7210 0 0 {name=x122}
C {lab_pin.sym} -1830 -7240 0 0 {name=p727 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7220 0 0 {name=p728 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7200 0 0 {name=p729 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -7180 0 0 {name=p730 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7240 0 0 {name=p731 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7220 0 0 {name=p732 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7300 0 0 {name=x123}
C {lab_pin.sym} -1830 -7330 0 0 {name=p733 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7310 0 0 {name=p734 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7290 0 0 {name=p735 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -7270 0 0 {name=p736 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7330 0 0 {name=p737 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7310 0 0 {name=p738 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7400 0 0 {name=x124}
C {lab_pin.sym} -1830 -7430 0 0 {name=p739 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7410 0 0 {name=p740 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7390 0 0 {name=p741 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -7370 0 0 {name=p742 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7430 0 0 {name=p743 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7410 0 0 {name=p744 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7490 0 0 {name=x125}
C {lab_pin.sym} -1830 -7520 0 0 {name=p745 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7500 0 0 {name=p746 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7480 0 0 {name=p747 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -7460 0 0 {name=p748 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7520 0 0 {name=p749 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7500 0 0 {name=p750 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7590 0 0 {name=x126}
C {lab_pin.sym} -1830 -7620 0 0 {name=p751 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7600 0 0 {name=p752 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7580 0 0 {name=p753 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -7560 0 0 {name=p754 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7620 0 0 {name=p755 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7600 0 0 {name=p756 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7680 0 0 {name=x127}
C {lab_pin.sym} -1830 -7710 0 0 {name=p757 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7690 0 0 {name=p758 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7670 0 0 {name=p759 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -7650 0 0 {name=p760 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7710 0 0 {name=p761 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7690 0 0 {name=p762 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2000 -7780 0 0 {name=x128}
C {lab_pin.sym} -1830 -7810 0 0 {name=p763 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -1830 -7790 0 0 {name=p764 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -1830 -7770 0 0 {name=p765 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -1830 -7750 0 0 {name=p766 sig_type=std_logic lab=CLKR[1]}
C {lab_pin.sym} -2170 -7810 0 0 {name=p767 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2170 -7790 0 0 {name=p768 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -1670 0 0 {name=x129}
C {lab_pin.sym} -2260 -1700 0 0 {name=p769 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -1680 0 0 {name=p770 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -1660 0 0 {name=p771 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -1640 0 0 {name=p772 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -1700 0 0 {name=p773 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -1680 0 0 {name=p774 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -1770 0 0 {name=x130}
C {lab_pin.sym} -2260 -1800 0 0 {name=p775 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -1780 0 0 {name=p776 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -1760 0 0 {name=p777 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -1740 0 0 {name=p778 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -1800 0 0 {name=p779 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -1780 0 0 {name=p780 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -1870 0 0 {name=x131}
C {lab_pin.sym} -2260 -1900 0 0 {name=p781 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -1880 0 0 {name=p782 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -1860 0 0 {name=p783 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -1840 0 0 {name=p784 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -1900 0 0 {name=p785 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -1880 0 0 {name=p786 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -1970 0 0 {name=x132}
C {lab_pin.sym} -2260 -2000 0 0 {name=p787 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -1980 0 0 {name=p788 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -1960 0 0 {name=p789 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -1940 0 0 {name=p790 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2000 0 0 {name=p791 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -1980 0 0 {name=p792 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2070 0 0 {name=x133}
C {lab_pin.sym} -2260 -2100 0 0 {name=p793 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2080 0 0 {name=p794 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2060 0 0 {name=p795 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2040 0 0 {name=p796 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2100 0 0 {name=p797 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2080 0 0 {name=p798 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2170 0 0 {name=x134}
C {lab_pin.sym} -2260 -2200 0 0 {name=p799 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2180 0 0 {name=p800 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2160 0 0 {name=p801 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2140 0 0 {name=p802 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2200 0 0 {name=p803 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2180 0 0 {name=p804 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2270 0 0 {name=x135}
C {lab_pin.sym} -2260 -2300 0 0 {name=p805 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2280 0 0 {name=p806 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2260 0 0 {name=p807 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2240 0 0 {name=p808 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2300 0 0 {name=p809 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2280 0 0 {name=p810 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2370 0 0 {name=x136}
C {lab_pin.sym} -2260 -2400 0 0 {name=p811 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2380 0 0 {name=p812 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2360 0 0 {name=p813 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2340 0 0 {name=p814 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2400 0 0 {name=p815 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2380 0 0 {name=p816 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2470 0 0 {name=x137}
C {lab_pin.sym} -2260 -2500 0 0 {name=p817 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2480 0 0 {name=p818 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2460 0 0 {name=p819 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2440 0 0 {name=p820 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2500 0 0 {name=p821 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2480 0 0 {name=p822 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2570 0 0 {name=x138}
C {lab_pin.sym} -2260 -2600 0 0 {name=p823 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2580 0 0 {name=p824 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2560 0 0 {name=p825 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2540 0 0 {name=p826 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2600 0 0 {name=p827 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2580 0 0 {name=p828 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2670 0 0 {name=x139}
C {lab_pin.sym} -2260 -2700 0 0 {name=p829 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2680 0 0 {name=p830 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2660 0 0 {name=p831 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2640 0 0 {name=p832 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2700 0 0 {name=p833 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2680 0 0 {name=p834 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2770 0 0 {name=x140}
C {lab_pin.sym} -2260 -2800 0 0 {name=p835 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2780 0 0 {name=p836 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2760 0 0 {name=p837 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2740 0 0 {name=p838 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2800 0 0 {name=p839 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2780 0 0 {name=p840 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2870 0 0 {name=x141}
C {lab_pin.sym} -2260 -2900 0 0 {name=p841 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2880 0 0 {name=p842 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2860 0 0 {name=p843 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2840 0 0 {name=p844 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -2900 0 0 {name=p845 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2880 0 0 {name=p846 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -2970 0 0 {name=x142}
C {lab_pin.sym} -2260 -3000 0 0 {name=p847 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -2980 0 0 {name=p848 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -2960 0 0 {name=p849 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -2940 0 0 {name=p850 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3000 0 0 {name=p851 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -2980 0 0 {name=p852 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3070 0 0 {name=x143}
C {lab_pin.sym} -2260 -3100 0 0 {name=p853 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3080 0 0 {name=p854 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3060 0 0 {name=p855 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3040 0 0 {name=p856 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3100 0 0 {name=p857 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3080 0 0 {name=p858 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3170 0 0 {name=x144}
C {lab_pin.sym} -2260 -3200 0 0 {name=p859 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3180 0 0 {name=p860 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3160 0 0 {name=p861 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3140 0 0 {name=p862 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3200 0 0 {name=p863 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3180 0 0 {name=p864 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3280 0 0 {name=x145}
C {lab_pin.sym} -2260 -3310 0 0 {name=p865 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3290 0 0 {name=p866 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3270 0 0 {name=p867 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3250 0 0 {name=p868 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3310 0 0 {name=p869 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3290 0 0 {name=p870 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3380 0 0 {name=x146}
C {lab_pin.sym} -2260 -3410 0 0 {name=p871 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3390 0 0 {name=p872 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3370 0 0 {name=p873 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3350 0 0 {name=p874 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3410 0 0 {name=p875 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3390 0 0 {name=p876 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3480 0 0 {name=x147}
C {lab_pin.sym} -2260 -3510 0 0 {name=p877 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3490 0 0 {name=p878 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3470 0 0 {name=p879 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3450 0 0 {name=p880 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3510 0 0 {name=p881 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3490 0 0 {name=p882 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3580 0 0 {name=x148}
C {lab_pin.sym} -2260 -3610 0 0 {name=p883 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3590 0 0 {name=p884 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3570 0 0 {name=p885 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3550 0 0 {name=p886 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3610 0 0 {name=p887 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3590 0 0 {name=p888 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3680 0 0 {name=x149}
C {lab_pin.sym} -2260 -3710 0 0 {name=p889 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3690 0 0 {name=p890 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3670 0 0 {name=p891 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3650 0 0 {name=p892 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3710 0 0 {name=p893 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3690 0 0 {name=p894 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3780 0 0 {name=x150}
C {lab_pin.sym} -2260 -3810 0 0 {name=p895 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3790 0 0 {name=p896 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3770 0 0 {name=p897 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3750 0 0 {name=p898 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3810 0 0 {name=p899 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3790 0 0 {name=p900 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3880 0 0 {name=x151}
C {lab_pin.sym} -2260 -3910 0 0 {name=p901 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3890 0 0 {name=p902 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3870 0 0 {name=p903 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3850 0 0 {name=p904 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -3910 0 0 {name=p905 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3890 0 0 {name=p906 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -3980 0 0 {name=x152}
C {lab_pin.sym} -2260 -4010 0 0 {name=p907 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -3990 0 0 {name=p908 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -3970 0 0 {name=p909 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -3950 0 0 {name=p910 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4010 0 0 {name=p911 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -3990 0 0 {name=p912 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4080 0 0 {name=x153}
C {lab_pin.sym} -2260 -4110 0 0 {name=p913 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4090 0 0 {name=p914 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4070 0 0 {name=p915 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4050 0 0 {name=p916 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4110 0 0 {name=p917 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4090 0 0 {name=p918 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4180 0 0 {name=x154}
C {lab_pin.sym} -2260 -4210 0 0 {name=p919 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4190 0 0 {name=p920 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4170 0 0 {name=p921 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4150 0 0 {name=p922 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4210 0 0 {name=p923 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4190 0 0 {name=p924 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4280 0 0 {name=x155}
C {lab_pin.sym} -2260 -4310 0 0 {name=p925 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4290 0 0 {name=p926 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4270 0 0 {name=p927 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4250 0 0 {name=p928 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4310 0 0 {name=p929 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4290 0 0 {name=p930 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4380 0 0 {name=x156}
C {lab_pin.sym} -2260 -4410 0 0 {name=p931 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4390 0 0 {name=p932 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4370 0 0 {name=p933 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4350 0 0 {name=p934 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4410 0 0 {name=p935 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4390 0 0 {name=p936 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4480 0 0 {name=x157}
C {lab_pin.sym} -2260 -4510 0 0 {name=p937 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4490 0 0 {name=p938 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4470 0 0 {name=p939 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4450 0 0 {name=p940 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4510 0 0 {name=p941 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4490 0 0 {name=p942 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4580 0 0 {name=x158}
C {lab_pin.sym} -2260 -4610 0 0 {name=p943 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4590 0 0 {name=p944 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4570 0 0 {name=p945 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4550 0 0 {name=p946 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4610 0 0 {name=p947 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4590 0 0 {name=p948 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4680 0 0 {name=x159}
C {lab_pin.sym} -2260 -4710 0 0 {name=p949 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4690 0 0 {name=p950 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4670 0 0 {name=p951 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4650 0 0 {name=p952 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4710 0 0 {name=p953 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4690 0 0 {name=p954 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4780 0 0 {name=x160}
C {lab_pin.sym} -2260 -4810 0 0 {name=p955 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4790 0 0 {name=p956 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4770 0 0 {name=p957 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4750 0 0 {name=p958 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4810 0 0 {name=p959 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4790 0 0 {name=p960 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4890 0 0 {name=x161}
C {lab_pin.sym} -2260 -4920 0 0 {name=p961 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -4900 0 0 {name=p962 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4880 0 0 {name=p963 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4860 0 0 {name=p964 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -4920 0 0 {name=p965 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -4900 0 0 {name=p966 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -4990 0 0 {name=x162}
C {lab_pin.sym} -2260 -5020 0 0 {name=p967 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5000 0 0 {name=p968 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -4980 0 0 {name=p969 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -4960 0 0 {name=p970 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5020 0 0 {name=p971 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5000 0 0 {name=p972 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5090 0 0 {name=x163}
C {lab_pin.sym} -2260 -5120 0 0 {name=p973 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5100 0 0 {name=p974 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5080 0 0 {name=p975 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5060 0 0 {name=p976 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5120 0 0 {name=p977 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5100 0 0 {name=p978 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5190 0 0 {name=x164}
C {lab_pin.sym} -2260 -5220 0 0 {name=p979 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5200 0 0 {name=p980 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5180 0 0 {name=p981 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5160 0 0 {name=p982 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5220 0 0 {name=p983 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5200 0 0 {name=p984 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5290 0 0 {name=x165}
C {lab_pin.sym} -2260 -5320 0 0 {name=p985 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5300 0 0 {name=p986 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5280 0 0 {name=p987 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5260 0 0 {name=p988 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5320 0 0 {name=p989 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5300 0 0 {name=p990 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5390 0 0 {name=x166}
C {lab_pin.sym} -2260 -5420 0 0 {name=p991 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5400 0 0 {name=p992 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5380 0 0 {name=p993 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5360 0 0 {name=p994 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5420 0 0 {name=p995 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5400 0 0 {name=p996 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5490 0 0 {name=x167}
C {lab_pin.sym} -2260 -5520 0 0 {name=p997 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5500 0 0 {name=p998 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5480 0 0 {name=p999 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5460 0 0 {name=p1000 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5520 0 0 {name=p1001 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5500 0 0 {name=p1002 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5590 0 0 {name=x168}
C {lab_pin.sym} -2260 -5620 0 0 {name=p1003 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5600 0 0 {name=p1004 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5580 0 0 {name=p1005 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5560 0 0 {name=p1006 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5620 0 0 {name=p1007 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5600 0 0 {name=p1008 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5690 0 0 {name=x169}
C {lab_pin.sym} -2260 -5720 0 0 {name=p1009 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5700 0 0 {name=p1010 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5680 0 0 {name=p1011 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5660 0 0 {name=p1012 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5720 0 0 {name=p1013 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5700 0 0 {name=p1014 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5790 0 0 {name=x170}
C {lab_pin.sym} -2260 -5820 0 0 {name=p1015 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5800 0 0 {name=p1016 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5780 0 0 {name=p1017 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5760 0 0 {name=p1018 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5820 0 0 {name=p1019 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5800 0 0 {name=p1020 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5890 0 0 {name=x171}
C {lab_pin.sym} -2260 -5920 0 0 {name=p1021 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -5900 0 0 {name=p1022 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5880 0 0 {name=p1023 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5860 0 0 {name=p1024 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -5920 0 0 {name=p1025 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -5900 0 0 {name=p1026 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -5990 0 0 {name=x172}
C {lab_pin.sym} -2260 -6020 0 0 {name=p1027 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6000 0 0 {name=p1028 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -5980 0 0 {name=p1029 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -5960 0 0 {name=p1030 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6020 0 0 {name=p1031 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6000 0 0 {name=p1032 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6090 0 0 {name=x173}
C {lab_pin.sym} -2260 -6120 0 0 {name=p1033 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6100 0 0 {name=p1034 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6080 0 0 {name=p1035 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6060 0 0 {name=p1036 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6120 0 0 {name=p1037 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6100 0 0 {name=p1038 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6190 0 0 {name=x174}
C {lab_pin.sym} -2260 -6220 0 0 {name=p1039 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6200 0 0 {name=p1040 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6180 0 0 {name=p1041 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6160 0 0 {name=p1042 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6220 0 0 {name=p1043 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6200 0 0 {name=p1044 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6290 0 0 {name=x175}
C {lab_pin.sym} -2260 -6320 0 0 {name=p1045 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6300 0 0 {name=p1046 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6280 0 0 {name=p1047 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6260 0 0 {name=p1048 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6320 0 0 {name=p1049 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6300 0 0 {name=p1050 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6390 0 0 {name=x176}
C {lab_pin.sym} -2260 -6420 0 0 {name=p1051 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6400 0 0 {name=p1052 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6380 0 0 {name=p1053 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6360 0 0 {name=p1054 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6420 0 0 {name=p1055 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6400 0 0 {name=p1056 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6500 0 0 {name=x177}
C {lab_pin.sym} -2260 -6530 0 0 {name=p1057 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6510 0 0 {name=p1058 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6490 0 0 {name=p1059 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6470 0 0 {name=p1060 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6530 0 0 {name=p1061 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6510 0 0 {name=p1062 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6600 0 0 {name=x178}
C {lab_pin.sym} -2260 -6630 0 0 {name=p1063 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6610 0 0 {name=p1064 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6590 0 0 {name=p1065 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6570 0 0 {name=p1066 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6630 0 0 {name=p1067 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6610 0 0 {name=p1068 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6700 0 0 {name=x179}
C {lab_pin.sym} -2260 -6730 0 0 {name=p1069 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6710 0 0 {name=p1070 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6690 0 0 {name=p1071 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6670 0 0 {name=p1072 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6730 0 0 {name=p1073 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6710 0 0 {name=p1074 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6800 0 0 {name=x180}
C {lab_pin.sym} -2260 -6830 0 0 {name=p1075 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6810 0 0 {name=p1076 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6790 0 0 {name=p1077 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6770 0 0 {name=p1078 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6830 0 0 {name=p1079 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6810 0 0 {name=p1080 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -6900 0 0 {name=x181}
C {lab_pin.sym} -2260 -6930 0 0 {name=p1081 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -6910 0 0 {name=p1082 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6890 0 0 {name=p1083 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6870 0 0 {name=p1084 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -6930 0 0 {name=p1085 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -6910 0 0 {name=p1086 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7000 0 0 {name=x182}
C {lab_pin.sym} -2260 -7030 0 0 {name=p1087 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7010 0 0 {name=p1088 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -6990 0 0 {name=p1089 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -6970 0 0 {name=p1090 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7030 0 0 {name=p1091 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7010 0 0 {name=p1092 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7100 0 0 {name=x183}
C {lab_pin.sym} -2260 -7130 0 0 {name=p1093 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7110 0 0 {name=p1094 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7090 0 0 {name=p1095 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7070 0 0 {name=p1096 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7130 0 0 {name=p1097 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7110 0 0 {name=p1098 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7200 0 0 {name=x184}
C {lab_pin.sym} -2260 -7230 0 0 {name=p1099 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7210 0 0 {name=p1100 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7190 0 0 {name=p1101 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7170 0 0 {name=p1102 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7230 0 0 {name=p1103 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7210 0 0 {name=p1104 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7300 0 0 {name=x185}
C {lab_pin.sym} -2260 -7330 0 0 {name=p1105 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7310 0 0 {name=p1106 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7290 0 0 {name=p1107 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7270 0 0 {name=p1108 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7330 0 0 {name=p1109 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7310 0 0 {name=p1110 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7400 0 0 {name=x186}
C {lab_pin.sym} -2260 -7430 0 0 {name=p1111 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7410 0 0 {name=p1112 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7390 0 0 {name=p1113 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7370 0 0 {name=p1114 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7430 0 0 {name=p1115 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7410 0 0 {name=p1116 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7500 0 0 {name=x187}
C {lab_pin.sym} -2260 -7530 0 0 {name=p1117 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7510 0 0 {name=p1118 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7490 0 0 {name=p1119 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7470 0 0 {name=p1120 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7530 0 0 {name=p1121 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7510 0 0 {name=p1122 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7600 0 0 {name=x188}
C {lab_pin.sym} -2260 -7630 0 0 {name=p1123 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7610 0 0 {name=p1124 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7590 0 0 {name=p1125 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7570 0 0 {name=p1126 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7630 0 0 {name=p1127 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7610 0 0 {name=p1128 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7700 0 0 {name=x189}
C {lab_pin.sym} -2260 -7730 0 0 {name=p1129 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7710 0 0 {name=p1130 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7690 0 0 {name=p1131 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7670 0 0 {name=p1132 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7730 0 0 {name=p1133 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7710 0 0 {name=p1134 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7800 0 0 {name=x190}
C {lab_pin.sym} -2260 -7830 0 0 {name=p1135 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7810 0 0 {name=p1136 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7790 0 0 {name=p1137 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7770 0 0 {name=p1138 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7830 0 0 {name=p1139 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7810 0 0 {name=p1140 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -7900 0 0 {name=x191}
C {lab_pin.sym} -2260 -7930 0 0 {name=p1141 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -7910 0 0 {name=p1142 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7890 0 0 {name=p1143 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7870 0 0 {name=p1144 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -7930 0 0 {name=p1145 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -7910 0 0 {name=p1146 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2430 -8000 0 0 {name=x192}
C {lab_pin.sym} -2260 -8030 0 0 {name=p1147 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2260 -8010 0 0 {name=p1148 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2260 -7990 0 0 {name=p1149 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2260 -7970 0 0 {name=p1150 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2600 -8030 0 0 {name=p1151 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2600 -8010 0 0 {name=p1152 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8130 0 0 {name=x193}
C {lab_pin.sym} -2250 -8160 0 0 {name=p1153 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8140 0 0 {name=p1154 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8120 0 0 {name=p1155 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8100 0 0 {name=p1156 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8160 0 0 {name=p1157 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8140 0 0 {name=p1158 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8230 0 0 {name=x194}
C {lab_pin.sym} -2250 -8260 0 0 {name=p1159 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8240 0 0 {name=p1160 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8220 0 0 {name=p1161 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8200 0 0 {name=p1162 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8260 0 0 {name=p1163 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8240 0 0 {name=p1164 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8330 0 0 {name=x195}
C {lab_pin.sym} -2250 -8360 0 0 {name=p1165 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8340 0 0 {name=p1166 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8320 0 0 {name=p1167 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8300 0 0 {name=p1168 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8360 0 0 {name=p1169 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8340 0 0 {name=p1170 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8430 0 0 {name=x196}
C {lab_pin.sym} -2250 -8460 0 0 {name=p1171 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8440 0 0 {name=p1172 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8420 0 0 {name=p1173 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8400 0 0 {name=p1174 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8460 0 0 {name=p1175 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8440 0 0 {name=p1176 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8530 0 0 {name=x197}
C {lab_pin.sym} -2250 -8560 0 0 {name=p1177 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8540 0 0 {name=p1178 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8520 0 0 {name=p1179 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8500 0 0 {name=p1180 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8560 0 0 {name=p1181 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8540 0 0 {name=p1182 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8630 0 0 {name=x198}
C {lab_pin.sym} -2250 -8660 0 0 {name=p1183 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8640 0 0 {name=p1184 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8620 0 0 {name=p1185 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8600 0 0 {name=p1186 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8660 0 0 {name=p1187 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8640 0 0 {name=p1188 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8730 0 0 {name=x199}
C {lab_pin.sym} -2250 -8760 0 0 {name=p1189 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8740 0 0 {name=p1190 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8720 0 0 {name=p1191 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8700 0 0 {name=p1192 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8760 0 0 {name=p1193 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8740 0 0 {name=p1194 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8830 0 0 {name=x200}
C {lab_pin.sym} -2250 -8860 0 0 {name=p1195 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8840 0 0 {name=p1196 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8820 0 0 {name=p1197 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8800 0 0 {name=p1198 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8860 0 0 {name=p1199 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8840 0 0 {name=p1200 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -8930 0 0 {name=x201}
C {lab_pin.sym} -2250 -8960 0 0 {name=p1201 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -8940 0 0 {name=p1202 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -8920 0 0 {name=p1203 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -8900 0 0 {name=p1204 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -8960 0 0 {name=p1205 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -8940 0 0 {name=p1206 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9030 0 0 {name=x202}
C {lab_pin.sym} -2250 -9060 0 0 {name=p1207 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9040 0 0 {name=p1208 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9020 0 0 {name=p1209 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9000 0 0 {name=p1210 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9060 0 0 {name=p1211 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9040 0 0 {name=p1212 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9130 0 0 {name=x203}
C {lab_pin.sym} -2250 -9160 0 0 {name=p1213 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9140 0 0 {name=p1214 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9120 0 0 {name=p1215 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9100 0 0 {name=p1216 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9160 0 0 {name=p1217 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9140 0 0 {name=p1218 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9230 0 0 {name=x204}
C {lab_pin.sym} -2250 -9260 0 0 {name=p1219 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9240 0 0 {name=p1220 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9220 0 0 {name=p1221 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9200 0 0 {name=p1222 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9260 0 0 {name=p1223 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9240 0 0 {name=p1224 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9330 0 0 {name=x205}
C {lab_pin.sym} -2250 -9360 0 0 {name=p1225 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9340 0 0 {name=p1226 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9320 0 0 {name=p1227 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9300 0 0 {name=p1228 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9360 0 0 {name=p1229 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9340 0 0 {name=p1230 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9430 0 0 {name=x206}
C {lab_pin.sym} -2250 -9460 0 0 {name=p1231 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9440 0 0 {name=p1232 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9420 0 0 {name=p1233 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9400 0 0 {name=p1234 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9460 0 0 {name=p1235 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9440 0 0 {name=p1236 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9530 0 0 {name=x207}
C {lab_pin.sym} -2250 -9560 0 0 {name=p1237 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9540 0 0 {name=p1238 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9520 0 0 {name=p1239 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9500 0 0 {name=p1240 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9560 0 0 {name=p1241 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9540 0 0 {name=p1242 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9630 0 0 {name=x208}
C {lab_pin.sym} -2250 -9660 0 0 {name=p1243 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9640 0 0 {name=p1244 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9620 0 0 {name=p1245 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9600 0 0 {name=p1246 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9660 0 0 {name=p1247 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9640 0 0 {name=p1248 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9740 0 0 {name=x209}
C {lab_pin.sym} -2250 -9770 0 0 {name=p1249 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9750 0 0 {name=p1250 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9730 0 0 {name=p1251 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9710 0 0 {name=p1252 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9770 0 0 {name=p1253 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9750 0 0 {name=p1254 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9840 0 0 {name=x210}
C {lab_pin.sym} -2250 -9870 0 0 {name=p1255 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9850 0 0 {name=p1256 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9830 0 0 {name=p1257 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9810 0 0 {name=p1258 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9870 0 0 {name=p1259 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9850 0 0 {name=p1260 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -9940 0 0 {name=x211}
C {lab_pin.sym} -2250 -9970 0 0 {name=p1261 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -9950 0 0 {name=p1262 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -9930 0 0 {name=p1263 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -9910 0 0 {name=p1264 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -9970 0 0 {name=p1265 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -9950 0 0 {name=p1266 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10040 0 0 {name=x212}
C {lab_pin.sym} -2250 -10070 0 0 {name=p1267 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10050 0 0 {name=p1268 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10030 0 0 {name=p1269 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10010 0 0 {name=p1270 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10070 0 0 {name=p1271 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10050 0 0 {name=p1272 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10140 0 0 {name=x213}
C {lab_pin.sym} -2250 -10170 0 0 {name=p1273 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10150 0 0 {name=p1274 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10130 0 0 {name=p1275 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10110 0 0 {name=p1276 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10170 0 0 {name=p1277 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10150 0 0 {name=p1278 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10240 0 0 {name=x214}
C {lab_pin.sym} -2250 -10270 0 0 {name=p1279 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10250 0 0 {name=p1280 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10230 0 0 {name=p1281 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10210 0 0 {name=p1282 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10270 0 0 {name=p1283 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10250 0 0 {name=p1284 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10340 0 0 {name=x215}
C {lab_pin.sym} -2250 -10370 0 0 {name=p1285 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10350 0 0 {name=p1286 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10330 0 0 {name=p1287 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10310 0 0 {name=p1288 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10370 0 0 {name=p1289 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10350 0 0 {name=p1290 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10440 0 0 {name=x216}
C {lab_pin.sym} -2250 -10470 0 0 {name=p1291 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10450 0 0 {name=p1292 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10430 0 0 {name=p1293 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10410 0 0 {name=p1294 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10470 0 0 {name=p1295 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10450 0 0 {name=p1296 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10540 0 0 {name=x217}
C {lab_pin.sym} -2250 -10570 0 0 {name=p1297 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10550 0 0 {name=p1298 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10530 0 0 {name=p1299 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10510 0 0 {name=p1300 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10570 0 0 {name=p1301 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10550 0 0 {name=p1302 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10640 0 0 {name=x218}
C {lab_pin.sym} -2250 -10670 0 0 {name=p1303 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10650 0 0 {name=p1304 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10630 0 0 {name=p1305 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10610 0 0 {name=p1306 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10670 0 0 {name=p1307 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10650 0 0 {name=p1308 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10740 0 0 {name=x219}
C {lab_pin.sym} -2250 -10770 0 0 {name=p1309 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10750 0 0 {name=p1310 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10730 0 0 {name=p1311 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10710 0 0 {name=p1312 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10770 0 0 {name=p1313 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10750 0 0 {name=p1314 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10840 0 0 {name=x220}
C {lab_pin.sym} -2250 -10870 0 0 {name=p1315 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10850 0 0 {name=p1316 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10830 0 0 {name=p1317 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10810 0 0 {name=p1318 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10870 0 0 {name=p1319 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10850 0 0 {name=p1320 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -10940 0 0 {name=x221}
C {lab_pin.sym} -2250 -10970 0 0 {name=p1321 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -10950 0 0 {name=p1322 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -10930 0 0 {name=p1323 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -10910 0 0 {name=p1324 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -10970 0 0 {name=p1325 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -10950 0 0 {name=p1326 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11040 0 0 {name=x222}
C {lab_pin.sym} -2250 -11070 0 0 {name=p1327 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11050 0 0 {name=p1328 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11030 0 0 {name=p1329 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11010 0 0 {name=p1330 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11070 0 0 {name=p1331 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11050 0 0 {name=p1332 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11140 0 0 {name=x223}
C {lab_pin.sym} -2250 -11170 0 0 {name=p1333 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11150 0 0 {name=p1334 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11130 0 0 {name=p1335 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11110 0 0 {name=p1336 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11170 0 0 {name=p1337 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11150 0 0 {name=p1338 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11240 0 0 {name=x224}
C {lab_pin.sym} -2250 -11270 0 0 {name=p1339 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11250 0 0 {name=p1340 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11230 0 0 {name=p1341 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11210 0 0 {name=p1342 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11270 0 0 {name=p1343 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11250 0 0 {name=p1344 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11350 0 0 {name=x225}
C {lab_pin.sym} -2250 -11380 0 0 {name=p1345 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11360 0 0 {name=p1346 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11340 0 0 {name=p1347 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11320 0 0 {name=p1348 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11380 0 0 {name=p1349 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11360 0 0 {name=p1350 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11450 0 0 {name=x226}
C {lab_pin.sym} -2250 -11480 0 0 {name=p1351 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11460 0 0 {name=p1352 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11440 0 0 {name=p1353 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11420 0 0 {name=p1354 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11480 0 0 {name=p1355 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11460 0 0 {name=p1356 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11550 0 0 {name=x227}
C {lab_pin.sym} -2250 -11580 0 0 {name=p1357 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11560 0 0 {name=p1358 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11540 0 0 {name=p1359 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11520 0 0 {name=p1360 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11580 0 0 {name=p1361 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11560 0 0 {name=p1362 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11650 0 0 {name=x228}
C {lab_pin.sym} -2250 -11680 0 0 {name=p1363 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11660 0 0 {name=p1364 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11640 0 0 {name=p1365 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11620 0 0 {name=p1366 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11680 0 0 {name=p1367 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11660 0 0 {name=p1368 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11750 0 0 {name=x229}
C {lab_pin.sym} -2250 -11780 0 0 {name=p1369 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11760 0 0 {name=p1370 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11740 0 0 {name=p1371 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11720 0 0 {name=p1372 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11780 0 0 {name=p1373 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11760 0 0 {name=p1374 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11850 0 0 {name=x230}
C {lab_pin.sym} -2250 -11880 0 0 {name=p1375 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11860 0 0 {name=p1376 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11840 0 0 {name=p1377 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11820 0 0 {name=p1378 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11880 0 0 {name=p1379 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11860 0 0 {name=p1380 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -11950 0 0 {name=x231}
C {lab_pin.sym} -2250 -11980 0 0 {name=p1381 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -11960 0 0 {name=p1382 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -11940 0 0 {name=p1383 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -11920 0 0 {name=p1384 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -11980 0 0 {name=p1385 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -11960 0 0 {name=p1386 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12050 0 0 {name=x232}
C {lab_pin.sym} -2250 -12080 0 0 {name=p1387 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12060 0 0 {name=p1388 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12040 0 0 {name=p1389 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12020 0 0 {name=p1390 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12080 0 0 {name=p1391 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12060 0 0 {name=p1392 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12150 0 0 {name=x233}
C {lab_pin.sym} -2250 -12180 0 0 {name=p1393 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12160 0 0 {name=p1394 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12140 0 0 {name=p1395 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12120 0 0 {name=p1396 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12180 0 0 {name=p1397 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12160 0 0 {name=p1398 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12250 0 0 {name=x234}
C {lab_pin.sym} -2250 -12280 0 0 {name=p1399 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12260 0 0 {name=p1400 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12240 0 0 {name=p1401 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12220 0 0 {name=p1402 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12280 0 0 {name=p1403 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12260 0 0 {name=p1404 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12350 0 0 {name=x235}
C {lab_pin.sym} -2250 -12380 0 0 {name=p1405 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12360 0 0 {name=p1406 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12340 0 0 {name=p1407 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12320 0 0 {name=p1408 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12380 0 0 {name=p1409 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12360 0 0 {name=p1410 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12450 0 0 {name=x236}
C {lab_pin.sym} -2250 -12480 0 0 {name=p1411 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12460 0 0 {name=p1412 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12440 0 0 {name=p1413 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12420 0 0 {name=p1414 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12480 0 0 {name=p1415 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12460 0 0 {name=p1416 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12550 0 0 {name=x237}
C {lab_pin.sym} -2250 -12580 0 0 {name=p1417 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12560 0 0 {name=p1418 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12540 0 0 {name=p1419 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12520 0 0 {name=p1420 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12580 0 0 {name=p1421 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12560 0 0 {name=p1422 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12650 0 0 {name=x238}
C {lab_pin.sym} -2250 -12680 0 0 {name=p1423 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12660 0 0 {name=p1424 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12640 0 0 {name=p1425 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12620 0 0 {name=p1426 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12680 0 0 {name=p1427 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12660 0 0 {name=p1428 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12750 0 0 {name=x239}
C {lab_pin.sym} -2250 -12780 0 0 {name=p1429 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12760 0 0 {name=p1430 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12740 0 0 {name=p1431 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12720 0 0 {name=p1432 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12780 0 0 {name=p1433 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12760 0 0 {name=p1434 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12850 0 0 {name=x240}
C {lab_pin.sym} -2250 -12880 0 0 {name=p1435 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12860 0 0 {name=p1436 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12840 0 0 {name=p1437 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12820 0 0 {name=p1438 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12880 0 0 {name=p1439 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12860 0 0 {name=p1440 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -12960 0 0 {name=x241}
C {lab_pin.sym} -2250 -12990 0 0 {name=p1441 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -12970 0 0 {name=p1442 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -12950 0 0 {name=p1443 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -12930 0 0 {name=p1444 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -12990 0 0 {name=p1445 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -12970 0 0 {name=p1446 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13060 0 0 {name=x242}
C {lab_pin.sym} -2250 -13090 0 0 {name=p1447 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13070 0 0 {name=p1448 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13050 0 0 {name=p1449 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13030 0 0 {name=p1450 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13090 0 0 {name=p1451 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13070 0 0 {name=p1452 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13160 0 0 {name=x243}
C {lab_pin.sym} -2250 -13190 0 0 {name=p1453 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13170 0 0 {name=p1454 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13150 0 0 {name=p1455 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13130 0 0 {name=p1456 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13190 0 0 {name=p1457 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13170 0 0 {name=p1458 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13260 0 0 {name=x244}
C {lab_pin.sym} -2250 -13290 0 0 {name=p1459 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13270 0 0 {name=p1460 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13250 0 0 {name=p1461 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13230 0 0 {name=p1462 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13290 0 0 {name=p1463 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13270 0 0 {name=p1464 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13360 0 0 {name=x245}
C {lab_pin.sym} -2250 -13390 0 0 {name=p1465 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13370 0 0 {name=p1466 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13350 0 0 {name=p1467 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13330 0 0 {name=p1468 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13390 0 0 {name=p1469 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13370 0 0 {name=p1470 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13460 0 0 {name=x246}
C {lab_pin.sym} -2250 -13490 0 0 {name=p1471 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13470 0 0 {name=p1472 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13450 0 0 {name=p1473 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13430 0 0 {name=p1474 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13490 0 0 {name=p1475 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13470 0 0 {name=p1476 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13560 0 0 {name=x247}
C {lab_pin.sym} -2250 -13590 0 0 {name=p1477 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13570 0 0 {name=p1478 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13550 0 0 {name=p1479 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13530 0 0 {name=p1480 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13590 0 0 {name=p1481 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13570 0 0 {name=p1482 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13660 0 0 {name=x248}
C {lab_pin.sym} -2250 -13690 0 0 {name=p1483 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13670 0 0 {name=p1484 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13650 0 0 {name=p1485 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13630 0 0 {name=p1486 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13690 0 0 {name=p1487 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13670 0 0 {name=p1488 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13760 0 0 {name=x249}
C {lab_pin.sym} -2250 -13790 0 0 {name=p1489 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13770 0 0 {name=p1490 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13750 0 0 {name=p1491 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13730 0 0 {name=p1492 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13790 0 0 {name=p1493 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13770 0 0 {name=p1494 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13860 0 0 {name=x250}
C {lab_pin.sym} -2250 -13890 0 0 {name=p1495 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13870 0 0 {name=p1496 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13850 0 0 {name=p1497 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13830 0 0 {name=p1498 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13890 0 0 {name=p1499 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13870 0 0 {name=p1500 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -13960 0 0 {name=x251}
C {lab_pin.sym} -2250 -13990 0 0 {name=p1501 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -13970 0 0 {name=p1502 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -13950 0 0 {name=p1503 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -13930 0 0 {name=p1504 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -13990 0 0 {name=p1505 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -13970 0 0 {name=p1506 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -14060 0 0 {name=x252}
C {lab_pin.sym} -2250 -14090 0 0 {name=p1507 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -14070 0 0 {name=p1508 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -14050 0 0 {name=p1509 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -14030 0 0 {name=p1510 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -14090 0 0 {name=p1511 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -14070 0 0 {name=p1512 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -14160 0 0 {name=x253}
C {lab_pin.sym} -2250 -14190 0 0 {name=p1513 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -14170 0 0 {name=p1514 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -14150 0 0 {name=p1515 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -14130 0 0 {name=p1516 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -14190 0 0 {name=p1517 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -14170 0 0 {name=p1518 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -14260 0 0 {name=x254}
C {lab_pin.sym} -2250 -14290 0 0 {name=p1519 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -14270 0 0 {name=p1520 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -14250 0 0 {name=p1521 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -14230 0 0 {name=p1522 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -14290 0 0 {name=p1523 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -14270 0 0 {name=p1524 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -14360 0 0 {name=x255}
C {lab_pin.sym} -2250 -14390 0 0 {name=p1525 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -14370 0 0 {name=p1526 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -14350 0 0 {name=p1527 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -14330 0 0 {name=p1528 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -14390 0 0 {name=p1529 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -14370 0 0 {name=p1530 sig_type=std_logic lab=VIN}
C {/home/yihengfu/openmpw/tools-dev/sample_unit_N.sym} -2420 -14460 0 0 {name=x256}
C {lab_pin.sym} -2250 -14490 0 0 {name=p1531 sig_type=std_logic lab=VCM}
C {lab_pin.sym} -2250 -14470 0 0 {name=p1532 sig_type=std_logic lab=VCM_1}
C {lab_pin.sym} -2250 -14450 0 0 {name=p1533 sig_type=std_logic lab=agnd}
C {lab_pin.sym} -2250 -14430 0 0 {name=p1534 sig_type=std_logic lab=CLKR[0]}
C {lab_pin.sym} -2590 -14490 0 0 {name=p1535 sig_type=std_logic lab=vgateN}
C {lab_pin.sym} -2590 -14470 0 0 {name=p1536 sig_type=std_logic lab=VIN}
C {ipin.sym} -3330 -2480 0 0 {name=p1537 lab=VCM_1}
C {opin.sym} -3660 -2510 0 0 {name=p1538 lab=vgateN}
C {iopin.sym} -3500 -2510 0 0 {name=p1539 lab=VCM}
C {iopin.sym} -3500 -2480 0 0 {name=p1540 lab=agnd}
C {iopin.sym} -3500 -2450 0 0 {name=p1541 lab=CLKR[0:7]}
C {iopin.sym} -3500 -2410 0 0 {name=p1542 lab=CLK1D}
C {opin.sym} -3660 -2450 0 0 {name=p1544 lab=VIN}
