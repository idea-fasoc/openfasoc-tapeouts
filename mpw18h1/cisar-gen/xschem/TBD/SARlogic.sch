v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 690 -430 720 -430 {
lab=avdd}
N 690 -390 720 -390 {
lab=agnd}
N 550 -390 580 -390 {
lab=Valid}
N 550 -430 580 -430 {
lab=RSTn}
N 920 -430 950 -430 {
lab=avdd}
N 920 -390 950 -390 {
lab=agnd}
N 780 -390 810 -390 {
lab=Valid}
N 780 -430 810 -430 {
lab=RSTn}
N 1150 -430 1180 -430 {
lab=avdd}
N 1150 -390 1180 -390 {
lab=agnd}
N 1010 -390 1040 -390 {
lab=Valid}
N 1010 -430 1040 -430 {
lab=RSTn}
N 1380 -430 1410 -430 {
lab=avdd}
N 1380 -390 1410 -390 {
lab=agnd}
N 1240 -390 1270 -390 {
lab=Valid}
N 1240 -430 1270 -430 {
lab=RSTn}
N 1610 -430 1640 -430 {
lab=avdd}
N 1610 -390 1640 -390 {
lab=agnd}
N 1470 -390 1500 -390 {
lab=Valid}
N 1470 -430 1500 -430 {
lab=RSTn}
N 1840 -430 1870 -430 {
lab=avdd}
N 1840 -390 1870 -390 {
lab=agnd}
N 1700 -390 1730 -390 {
lab=Valid}
N 1700 -430 1730 -430 {
lab=RSTn}
N 2070 -430 2100 -430 {
lab=avdd}
N 2070 -390 2100 -390 {
lab=agnd}
N 1930 -390 1960 -390 {
lab=Valid}
N 1930 -430 1960 -430 {
lab=RSTn}
N 2300 -430 2330 -430 {
lab=avdd}
N 2300 -390 2330 -390 {
lab=agnd}
N 2160 -390 2190 -390 {
lab=Valid}
N 2160 -430 2190 -430 {
lab=RSTn}
N 2520 -430 2550 -430 {
lab=avdd}
N 2520 -390 2550 -390 {
lab=agnd}
N 2380 -390 2410 -390 {
lab=Valid}
N 2380 -430 2410 -430 {
lab=RSTn}
N 2750 -430 2780 -430 {
lab=avdd}
N 2750 -390 2780 -390 {
lab=agnd}
N 2610 -390 2640 -390 {
lab=Valid}
N 2610 -430 2640 -430 {
lab=RSTn}
N 2980 -430 3010 -430 {
lab=avdd}
N 2980 -390 3010 -390 {
lab=agnd}
N 2840 -390 2870 -390 {
lab=Valid}
N 2840 -430 2870 -430 {
lab=RSTn}
N 3210 -430 3240 -430 {
lab=avdd}
N 3210 -390 3240 -390 {
lab=agnd}
N 3070 -390 3100 -390 {
lab=Valid}
N 3070 -430 3100 -430 {
lab=RSTn}
N 3420 -430 3450 -430 {
lab=avdd}
N 3420 -390 3450 -390 {
lab=agnd}
N 3280 -390 3310 -390 {
lab=Valid}
N 3280 -430 3310 -430 {
lab=RSTn}
N 3650 -430 3680 -430 {
lab=avdd}
N 3650 -390 3680 -390 {
lab=agnd}
N 3510 -390 3540 -390 {
lab=Valid}
N 3510 -430 3540 -430 {
lab=RSTn}
N 690 -410 810 -410 {
lab=CLK<0>}
N 920 -410 1040 -410 {
lab=CLK<1>}
N 1150 -410 1270 -410 {
lab=CLK<2>}
N 1380 -410 1500 -410 {
lab=CLK<3>}
N 1610 -410 1730 -410 {
lab=CLK<4>}
N 1840 -410 1960 -410 {
lab=CLK<5>}
N 2070 -410 2190 -410 {
lab=CLK<6>}
N 2300 -410 2410 -410 {
lab=CLK<7>}
N 2520 -410 2640 -410 {
lab=CLK<8>}
N 2750 -410 2870 -410 {
lab=CLK<9>}
N 2980 -410 3100 -410 {
lab=CLK<10>}
N 3210 -410 3310 -410 {
lab=CLK<11>}
N 3420 -410 3540 -410 {
lab=CLK<12>}
N 520 -410 580 -410 {
lab=avdd}
N 3410 -290 3450 -290 {
lab=avdd}
N 3410 -250 3440 -250 {
lab=agnd}
N 3410 -270 3440 -270 {
lab=#net1}
N 3260 -270 3300 -270 {
lab=Valid}
N 3630 -290 3670 -290 {
lab=avdd}
N 3630 -250 3660 -250 {
lab=agnd}
N 3480 -270 3520 -270 {
lab=#net1}
N 3440 -270 3480 -270 {
lab=#net1}
N 3630 -270 3670 -270 {
lab=#net2}
N 3880 -320 3920 -320 {
lab=#net3}
N 3880 -340 3910 -340 {
lab=avdd}
N 3880 -300 3920 -300 {
lab=agnd}
N 3640 -190 3680 -190 {
lab=avdd}
N 3640 -150 3670 -150 {
lab=agnd}
N 3640 -170 3680 -170 {
lab=#net4}
N 3360 -190 3400 -190 {
lab=avdd}
N 3360 -150 3390 -150 {
lab=agnd}
N 3360 -170 3400 -170 {
lab=RSTn}
N 3400 -170 3530 -170 {
lab=RSTn}
N 3200 -170 3250 -170 {
lab=CLKs}
N 3730 -410 3730 -340 {
lab=CLK<13>}
N 3670 -270 3690 -270 {
lab=#net2}
N 3690 -320 3690 -270 {
lab=#net2}
N 3690 -320 3730 -320 {
lab=#net2}
N 3680 -170 3720 -170 {
lab=#net4}
N 3720 -300 3720 -170 {
lab=#net4}
N 3720 -300 3730 -300 {
lab=#net4}
N 3200 -170 3250 -170 {
lab=CLKs}
N 4060 -340 4100 -340 {
lab=avdd}
N 4060 -300 4100 -300 {
lab=agnd}
N 3920 -320 3950 -320 {
lab=#net3}
N 4060 -320 4100 -320 {
lab=CLKc}
N 3650 -410 3730 -410 {
lab=CLK<13>}
N 2510 -760 2550 -760 {
lab=avdd}
N 2510 -720 2540 -720 {
lab=agnd}
N 2510 -740 2540 -740 {
lab=#net5}
N 2540 -740 2580 -740 {
lab=#net5}
N 2740 -760 2780 -760 {
lab=avdd}
N 2740 -720 2770 -720 {
lab=agnd}
N 2740 -740 2770 -740 {
lab=#net6}
N 2770 -740 2810 -740 {
lab=#net6}
N 1810 -800 1850 -800 {
lab=avdd}
N 1810 -760 1840 -760 {
lab=agnd}
N 1810 -780 1840 -780 {
lab=#net7}
N 1840 -780 1880 -780 {
lab=#net7}
N 3410 -600 3450 -600 {
lab=avdd}
N 3410 -560 3440 -560 {
lab=agnd}
N 3640 -600 3680 -600 {
lab=avdd}
N 3640 -560 3670 -560 {
lab=agnd}
N 3640 -580 3670 -580 {
lab=CLKs}
N 3670 -580 3710 -580 {
lab=CLKs}
N 3410 -580 3530 -580 {
lab=#net8}
N 3210 -580 3300 -580 {
lab=#net9}
N 3220 -600 3270 -600 {
lab=avdd}
N 3220 -560 3270 -560 {
lab=agnd}
N 3000 -680 3050 -680 {
lab=avdd}
N 3000 -640 3050 -640 {
lab=agnd}
N 3090 -660 3090 -600 {
lab=#net10}
N 3000 -660 3090 -660 {
lab=#net10}
N 1880 -780 1950 -780 {
lab=#net7}
N 2250 -740 2400 -740 {
lab=#net11}
N 2250 -780 2290 -780 {
lab=avdd}
N 2250 -760 2290 -760 {
lab=agnd}
N 2580 -740 2630 -740 {
lab=#net5}
N 2810 -740 2810 -680 {
lab=#net6}
N 2810 -680 2870 -680 {
lab=#net6}
N 1700 -660 2870 -660 {
lab=CLK1D}
N 1700 -780 1700 -660 {
lab=CLK1D}
N 1700 -580 3090 -580 {
lab=CLK1D}
N 1700 -660 1700 -580 {
lab=CLK1D}
N 720 50 780 50 {
lab=avdd}
N 720 90 780 90 {
lab=agnd}
N 720 70 780 70 {
lab=xxx}
N 560 60 600 60 {
lab=CLK2D}
N 560 80 600 80 {
lab=CLK<0>}
N 1060 50 1120 50 {
lab=avdd}
N 1060 90 1120 90 {
lab=agnd}
N 1060 70 1120 70 {
lab=xxx}
N 900 60 940 60 {
lab=CLK2D}
N 900 80 940 80 {
lab=CLK<0>}
N 1400 60 1460 60 {
lab=avdd}
N 1400 100 1460 100 {
lab=agnd}
N 1400 80 1460 80 {
lab=xxx}
N 1240 70 1280 70 {
lab=CLK2D}
N 1240 90 1280 90 {
lab=CLK<0>}
N 1740 60 1800 60 {
lab=avdd}
N 1740 100 1800 100 {
lab=agnd}
N 1740 80 1800 80 {
lab=xxx}
N 1580 70 1620 70 {
lab=CLK2D}
N 1580 90 1620 90 {
lab=CLK<0>}
N 2120 60 2180 60 {
lab=avdd}
N 2120 100 2180 100 {
lab=agnd}
N 2120 80 2180 80 {
lab=xxx}
N 1960 70 2000 70 {
lab=CLK2D}
N 1960 90 2000 90 {
lab=CLK<0>}
N 2460 60 2520 60 {
lab=avdd}
N 2460 100 2520 100 {
lab=agnd}
N 2460 80 2520 80 {
lab=xxx}
N 2300 70 2340 70 {
lab=CLK2D}
N 2300 90 2340 90 {
lab=CLK<0>}
N 2870 50 2930 50 {
lab=avdd}
N 2870 90 2930 90 {
lab=agnd}
N 2870 70 2930 70 {
lab=xxx}
N 2710 60 2750 60 {
lab=CLK2D}
N 2710 80 2750 80 {
lab=CLK<0>}
N 3210 50 3270 50 {
lab=avdd}
N 3210 90 3270 90 {
lab=agnd}
N 3210 70 3270 70 {
lab=xxx}
N 3050 60 3090 60 {
lab=CLK2D}
N 3050 80 3090 80 {
lab=CLK<0>}
N 3550 60 3610 60 {
lab=avdd}
N 3550 100 3610 100 {
lab=agnd}
N 3550 80 3610 80 {
lab=xxx}
N 3390 70 3430 70 {
lab=CLK2D}
N 3390 90 3430 90 {
lab=CLK<0>}
N 3890 60 3950 60 {
lab=avdd}
N 3890 100 3950 100 {
lab=agnd}
N 3890 80 3950 80 {
lab=xxx}
N 3730 70 3770 70 {
lab=CLK2D}
N 3730 90 3770 90 {
lab=CLK<0>}
N 4270 60 4330 60 {
lab=avdd}
N 4270 100 4330 100 {
lab=agnd}
N 4270 80 4330 80 {
lab=xxx}
N 4110 70 4150 70 {
lab=CLK2D}
N 4110 90 4150 90 {
lab=CLK<0>}
N 4610 60 4670 60 {
lab=avdd}
N 4610 100 4670 100 {
lab=agnd}
N 4610 80 4670 80 {
lab=xxx}
N 4450 70 4490 70 {
lab=CLK2D}
N 4450 90 4490 90 {
lab=CLK<0>}
N 4960 50 5020 50 {
lab=avdd}
N 4960 90 5020 90 {
lab=agnd}
N 4960 70 5020 70 {
lab=xxx}
N 4800 60 4840 60 {
lab=CLK2D}
N 4800 80 4840 80 {
lab=CLK<0>}
C {DFF_withreset.sym} 630 -410 0 0 {name=x1}
C {lab_pin.sym} 710 -430 0 0 {name=p1 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 700 -390 0 0 {name=p2 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 570 -390 0 0 {name=p4 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 570 -430 0 0 {name=p3 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 860 -410 0 0 {name=x2}
C {lab_pin.sym} 940 -430 0 0 {name=p5 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 930 -390 0 0 {name=p6 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 800 -390 0 0 {name=p7 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 800 -430 0 0 {name=p8 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 1090 -410 0 0 {name=x3}
C {lab_pin.sym} 1170 -430 0 0 {name=p9 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 1160 -390 0 0 {name=p10 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1030 -390 0 0 {name=p11 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 1030 -430 0 0 {name=p12 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 1320 -410 0 0 {name=x4}
C {lab_pin.sym} 1400 -430 0 0 {name=p13 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 1390 -390 0 0 {name=p14 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1260 -390 0 0 {name=p15 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 1260 -430 0 0 {name=p16 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 1550 -410 0 0 {name=x5}
C {lab_pin.sym} 1630 -430 0 0 {name=p17 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 1620 -390 0 0 {name=p18 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1490 -390 0 0 {name=p19 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 1490 -430 0 0 {name=p20 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 1780 -410 0 0 {name=x6}
C {lab_pin.sym} 1860 -430 0 0 {name=p21 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 1850 -390 0 0 {name=p22 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1720 -390 0 0 {name=p23 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 1720 -430 0 0 {name=p24 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 2010 -410 0 0 {name=x7}
C {lab_pin.sym} 2090 -430 0 0 {name=p25 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2080 -390 0 0 {name=p26 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1950 -390 0 0 {name=p27 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 1950 -430 0 0 {name=p28 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 2240 -410 0 0 {name=x8}
C {lab_pin.sym} 2320 -430 0 0 {name=p29 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2310 -390 0 0 {name=p30 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 2180 -390 0 0 {name=p31 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 2180 -430 0 0 {name=p32 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 2460 -410 0 0 {name=x9}
C {lab_pin.sym} 2540 -430 0 0 {name=p33 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2530 -390 0 0 {name=p34 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 2400 -390 0 0 {name=p35 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 2400 -430 0 0 {name=p36 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 2690 -410 0 0 {name=x10}
C {lab_pin.sym} 2770 -430 0 0 {name=p37 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2760 -390 0 0 {name=p38 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 2630 -390 0 0 {name=p39 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 2630 -430 0 0 {name=p40 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 2920 -410 0 0 {name=x11}
C {lab_pin.sym} 3000 -430 0 0 {name=p41 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2990 -390 0 0 {name=p42 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 2860 -390 0 0 {name=p43 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 2860 -430 0 0 {name=p44 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 3150 -410 0 0 {name=x12}
C {lab_pin.sym} 3230 -430 0 0 {name=p45 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3220 -390 0 0 {name=p46 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3090 -390 0 0 {name=p47 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 3090 -430 0 0 {name=p48 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 3360 -410 0 0 {name=x13}
C {lab_pin.sym} 3440 -430 0 0 {name=p49 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3430 -390 0 0 {name=p50 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3300 -390 0 0 {name=p51 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 3300 -430 0 0 {name=p52 sig_type=std_logic lab=RSTn}
C {DFF_withreset.sym} 3590 -410 0 0 {name=x14}
C {lab_pin.sym} 3670 -430 0 0 {name=p53 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3660 -390 0 0 {name=p54 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3530 -390 0 0 {name=p55 sig_type=std_logic lab=Valid
}
C {lab_pin.sym} 3530 -430 0 0 {name=p56 sig_type=std_logic lab=RSTn}
C {lab_pin.sym} 560 -410 0 0 {name=p57 sig_type=std_logic lab=avdd}
C {INV.sym} 3360 -270 0 0 {name=x15}
C {lab_pin.sym} 3430 -290 0 0 {name=p58 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 3430 -250 0 0 {name=p59 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3280 -270 0 0 {name=p60 sig_type=std_logic lab=Valid}
C {INV.sym} 3580 -270 0 0 {name=x16}
C {lab_pin.sym} 3650 -290 0 0 {name=p61 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 3650 -250 0 0 {name=p62 sig_type=std_logic lab=agnd}
C {nor3.sym} 3810 -320 0 0 {name=x17}
C {lab_pin.sym} 3900 -340 0 0 {name=p63 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3890 -300 0 0 {name=p64 sig_type=std_logic lab=agnd}
C {INV.sym} 3590 -170 0 0 {name=x18}
C {lab_pin.sym} 3660 -190 0 0 {name=p65 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 3660 -150 0 0 {name=p66 sig_type=std_logic lab=agnd}
C {INV.sym} 3310 -170 0 0 {name=x19}
C {lab_pin.sym} 3380 -190 0 0 {name=p67 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 3380 -150 0 0 {name=p68 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3450 -170 0 0 {name=p69 sig_type=std_logic lab=RSTn}
C {lab_pin.sym} 3220 -170 0 0 {name=p70 sig_type=std_logic lab=CLKs}
C {INV.sym} 4010 -320 0 0 {name=x20}
C {lab_pin.sym} 4080 -340 0 0 {name=p71 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 4080 -300 0 0 {name=p72 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 4090 -320 0 0 {name=p73 sig_type=std_logic lab=CLKc}
C {lab_pin.sym} 730 -410 0 0 {name=p74 sig_type=std_logic lab=CLK<0>}
C {lab_pin.sym} 980 -410 0 0 {name=p75 sig_type=std_logic lab=CLK<1>}
C {lab_pin.sym} 1180 -410 0 0 {name=p76 sig_type=std_logic lab=CLK<2>}
C {lab_pin.sym} 1420 -410 0 0 {name=p77 sig_type=std_logic lab=CLK<3>}
C {lab_pin.sym} 1650 -410 0 0 {name=p78 sig_type=std_logic lab=CLK<4>}
C {lab_pin.sym} 1870 -410 0 0 {name=p79 sig_type=std_logic lab=CLK<5>}
C {lab_pin.sym} 2110 -410 0 0 {name=p80 sig_type=std_logic lab=CLK<6>}
C {lab_pin.sym} 2340 -410 0 0 {name=p81 sig_type=std_logic lab=CLK<7>}
C {lab_pin.sym} 2560 -410 0 0 {name=p82 sig_type=std_logic lab=CLK<8>}
C {lab_pin.sym} 2800 -410 0 0 {name=p83 sig_type=std_logic lab=CLK<9>}
C {lab_pin.sym} 3030 -410 0 0 {name=p84 sig_type=std_logic lab=CLK<10>}
C {lab_pin.sym} 3250 -410 0 0 {name=p85 sig_type=std_logic lab=CLK<11>}
C {lab_pin.sym} 3490 -410 0 0 {name=p86 sig_type=std_logic lab=CLK<12>}
C {lab_pin.sym} 3690 -410 0 0 {name=p87 sig_type=std_logic lab=CLK<13>}
C {Delay.sym} 2100 -760 0 0 {name=x21}
C {INV.sym} 2460 -740 0 0 {name=x22}
C {lab_pin.sym} 2530 -760 0 0 {name=p88 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 2530 -720 0 0 {name=p89 sig_type=std_logic lab=agnd}
C {INV.sym} 2690 -740 0 0 {name=x23}
C {lab_pin.sym} 2760 -760 0 0 {name=p90 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 2760 -720 0 0 {name=p91 sig_type=std_logic lab=agnd}
C {INV.sym} 1760 -780 0 0 {name=x24}
C {lab_pin.sym} 1830 -800 0 0 {name=p92 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 1830 -760 0 0 {name=p93 sig_type=std_logic lab=agnd}
C {INV.sym} 3360 -580 0 0 {name=x25}
C {lab_pin.sym} 3430 -600 0 0 {name=p94 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 3430 -560 0 0 {name=p95 sig_type=std_logic lab=agnd}
C {INV.sym} 3590 -580 0 0 {name=x26}
C {lab_pin.sym} 3660 -600 0 0 {name=p96 sig_type=std_logic lab=avdd
}
C {lab_pin.sym} 3660 -560 0 0 {name=p97 sig_type=std_logic lab=agnd}
C {nand.sym} 2930 -660 0 0 {name=x27}
C {nand.sym} 3150 -580 0 0 {name=x28}
C {lab_pin.sym} 3240 -600 0 0 {name=p98 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3240 -560 0 0 {name=p99 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3020 -680 0 0 {name=p100 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3020 -640 0 0 {name=p101 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 2270 -780 0 0 {name=p102 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2270 -760 0 0 {name=p103 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1700 -700 0 0 {name=p104 sig_type=std_logic lab=CLK1D}
C {lab_pin.sym} 3680 -580 0 0 {name=p105 sig_type=std_logic lab=CLKs}
C {nor.sym} 660 70 0 0 {name=x29}
C {lab_pin.sym} 750 50 0 0 {name=p106 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 750 90 0 0 {name=p107 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 580 60 0 0 {name=p108 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 580 80 0 0 {name=p109 sig_type=std_logic lab=CLK<0>}
C {lab_pin.sym} 750 70 0 0 {name=p110 sig_type=std_logic lab=CLKR<0>}
C {nor.sym} 1000 70 0 0 {name=x30}
C {lab_pin.sym} 1090 50 0 0 {name=p111 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 1090 90 0 0 {name=p112 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 920 60 0 0 {name=p113 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 920 80 0 0 {name=p114 sig_type=std_logic lab=CLK<1>}
C {lab_pin.sym} 1090 70 0 0 {name=p115 sig_type=std_logic lab=CLKR<1>}
C {nor.sym} 1340 80 0 0 {name=x31}
C {lab_pin.sym} 1430 60 0 0 {name=p116 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 1430 100 0 0 {name=p117 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1260 70 0 0 {name=p118 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 1260 90 0 0 {name=p119 sig_type=std_logic lab=CLK<2>}
C {lab_pin.sym} 1430 80 0 0 {name=p120 sig_type=std_logic lab=CLKR<2>}
C {nor.sym} 1680 80 0 0 {name=x32}
C {lab_pin.sym} 1770 60 0 0 {name=p121 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 1770 100 0 0 {name=p122 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1600 70 0 0 {name=p123 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 1600 90 0 0 {name=p124 sig_type=std_logic lab=CLK<3>}
C {lab_pin.sym} 1770 80 0 0 {name=p125 sig_type=std_logic lab=CLKR<3>}
C {nor.sym} 2060 80 0 0 {name=x33}
C {lab_pin.sym} 2150 60 0 0 {name=p126 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2150 100 0 0 {name=p127 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 1980 70 0 0 {name=p128 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 1980 90 0 0 {name=p129 sig_type=std_logic lab=CLK<4>}
C {lab_pin.sym} 2150 80 0 0 {name=p130 sig_type=std_logic lab=CLKR<4>}
C {nor.sym} 2400 80 0 0 {name=x34}
C {lab_pin.sym} 2490 60 0 0 {name=p131 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2490 100 0 0 {name=p132 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 2320 70 0 0 {name=p133 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 2320 90 0 0 {name=p134 sig_type=std_logic lab=CLK<5>}
C {lab_pin.sym} 2490 80 0 0 {name=p135 sig_type=std_logic lab=CLKR<5>}
C {nor.sym} 2810 70 0 0 {name=x35}
C {lab_pin.sym} 2900 50 0 0 {name=p136 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 2900 90 0 0 {name=p137 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 2730 60 0 0 {name=p138 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 2730 80 0 0 {name=p139 sig_type=std_logic lab=CLK<6>}
C {lab_pin.sym} 2900 70 0 0 {name=p140 sig_type=std_logic lab=CLKR<6>}
C {nor.sym} 3150 70 0 0 {name=x36}
C {lab_pin.sym} 3240 50 0 0 {name=p141 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3240 90 0 0 {name=p142 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3070 60 0 0 {name=p143 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 3070 80 0 0 {name=p144 sig_type=std_logic lab=CLK<7>}
C {lab_pin.sym} 3240 70 0 0 {name=p145 sig_type=std_logic lab=CLKR<7>}
C {nor.sym} 3490 80 0 0 {name=x37}
C {lab_pin.sym} 3580 60 0 0 {name=p146 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3580 100 0 0 {name=p147 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3410 70 0 0 {name=p148 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 3410 90 0 0 {name=p149 sig_type=std_logic lab=CLK<8>}
C {lab_pin.sym} 3580 80 0 0 {name=p150 sig_type=std_logic lab=CLKR<8>}
C {nor.sym} 3830 80 0 0 {name=x38}
C {lab_pin.sym} 3920 60 0 0 {name=p151 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 3920 100 0 0 {name=p152 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 3750 70 0 0 {name=p153 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 3750 90 0 0 {name=p154 sig_type=std_logic lab=CLK<9>}
C {lab_pin.sym} 3920 80 0 0 {name=p155 sig_type=std_logic lab=CLKR<9>}
C {nor.sym} 4210 80 0 0 {name=x39}
C {lab_pin.sym} 4300 60 0 0 {name=p156 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 4300 100 0 0 {name=p157 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 4130 70 0 0 {name=p158 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 4130 90 0 0 {name=p159 sig_type=std_logic lab=CLK<10>}
C {lab_pin.sym} 4300 80 0 0 {name=p160 sig_type=std_logic lab=CLKR<10>}
C {nor.sym} 4550 80 0 0 {name=x40}
C {lab_pin.sym} 4640 60 0 0 {name=p161 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 4640 100 0 0 {name=p162 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 4470 70 0 0 {name=p163 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 4470 90 0 0 {name=p164 sig_type=std_logic lab=CLK<11>}
C {lab_pin.sym} 4640 80 0 0 {name=p165 sig_type=std_logic lab=CLKR<11>}
C {nor.sym} 4900 70 0 0 {name=x41}
C {lab_pin.sym} 4990 50 0 0 {name=p166 sig_type=std_logic lab=avdd}
C {lab_pin.sym} 4990 90 0 0 {name=p167 sig_type=std_logic lab=agnd}
C {lab_pin.sym} 4820 60 0 0 {name=p168 sig_type=std_logic lab=CLK2D}
C {lab_pin.sym} 4820 80 0 0 {name=p169 sig_type=std_logic lab=CLK<12>}
C {lab_pin.sym} 4990 70 0 0 {name=p170 sig_type=std_logic lab=CLKR<12>}
C {ipin.sym} 360 -380 0 0 {name=p172 lab=Valid}
C {iopin.sym} 180 -420 0 0 {name=p173 lab=avdd}
C {iopin.sym} 180 -380 0 0 {name=p174 lab=agnd}
C {ipin.sym} 360 -420 0 0 {name=p175 lab=CLK1D}
C {ipin.sym} 360 -340 0 0 {name=p176 lab=CLK2D}
C {opin.sym} 400 -340 0 0 {name=p178 lab=CLKc}
C {opin.sym} 240 -180 0 0 {name=p179 lab=CLK<0>}
C {opin.sym} 240 -150 0 0 {name=p180 lab=CLK<1>}
C {opin.sym} 240 -110 0 0 {name=p181 lab=CLK<2>}
C {opin.sym} 240 -80 0 0 {name=p182 lab=CLK<3>}
C {opin.sym} 240 -50 0 0 {name=p183 lab=CLK<4>}
C {opin.sym} 240 -20 0 0 {name=p184 lab=CLK<5>}
C {opin.sym} 240 10 0 0 {name=p185 lab=CLK<6>}
C {opin.sym} 240 40 0 0 {name=p186 lab=CLK<7>}
C {opin.sym} 240 70 0 0 {name=p187 lab=CLK<8>}
C {opin.sym} 240 100 0 0 {name=p188 lab=CLK<9>}
C {opin.sym} 240 130 0 0 {name=p189 lab=CLK<10>}
C {opin.sym} 240 160 0 0 {name=p190 lab=CLK<11>}
C {opin.sym} 240 190 0 0 {name=p191 lab=CLK<12>}
C {opin.sym} 240 220 0 0 {name=p192 lab=CLK<13>}
C {opin.sym} 50 -180 0 0 {name=p193 lab=CLKR<0>}
C {opin.sym} 50 -150 0 0 {name=p194 lab=CLKR<1>}
C {opin.sym} 50 -110 0 0 {name=p195 lab=CLKR<2>}
C {opin.sym} 50 -80 0 0 {name=p196 lab=CLKR<3>}
C {opin.sym} 50 -50 0 0 {name=p197 lab=CLKR<4>}
C {opin.sym} 50 -20 0 0 {name=p198 lab=CLKR<5>}
C {opin.sym} 50 10 0 0 {name=p199 lab=CLKR<6>}
C {opin.sym} 50 40 0 0 {name=p200 lab=CLKR<7>}
C {opin.sym} 50 70 0 0 {name=p201 lab=CLKR<8>}
C {opin.sym} 50 100 0 0 {name=p202 lab=CLKR<9>}
C {opin.sym} 50 130 0 0 {name=p203 lab=CLKR<10>}
C {opin.sym} 50 160 0 0 {name=p204 lab=CLKR<11>}
C {opin.sym} 50 190 0 0 {name=p205 lab=CLKR<12>}
